3111, -163.29701, 60, 123.13265
3112, -138.10966, 60, 133.63081
3113, -144.80364, 60, 129.75669
3114, -128.17293, 60, 148.18369
3115, -132.05928, 60, 141.4442
3116, -125.86104, 60, 165.40418
3117, -125.84882, 60, 157.62444
3118, -131.42779, 60, 183.48751
3119, -127.55367, 60, 176.79353
3120, -147.14417, 60, 193.6455
3121, -140.40468, 60, 189.75916
3122, -164.84064, 60, 197.29639
3123, -157.06091, 60, 197.30861
3124, -184.786, 60, 192.05709
3125, -178.09202, 60, 195.93121
3126, -193.60009, 60, 174.66019
3127, -189.71375, 60, 181.39968
3128, -197.26191, 60, 158.62242
3129, -197.27413, 60, 166.40216
3130, -192.6192, 60, 139.65436
3131, -196.49333, 60, 146.34834
3132, -35.483738, 60, 214.39728
3133, -37.501218, 60, 221.91088
3134, -22.673179, 60, 199.21955
3135, -28.182922, 60, 204.71201
3136, -5.6186516, 60, 192.50266
3137, -13.138552, 60, 194.49652
3138, 13.070263, 60, 194.15649
3139, 5.6037876, 60, 192.13908
3140, 28.455418, 60, 204.87903
3141, 22.962956, 60, 199.36929
3142, 37.448382, 60, 222.95247
3143, 35.454443, 60, 215.47969
3144, 33.694294, 60, 242.38756
3145, 35.711774, 60, 234.87396
3146, 22.859849, 60, 256.81584
3147, 28.410489, 60, 251.29997
3148, 6.6435912, 60, 266.35703
3149, 14.169718, 60, 264.3868
3150, -14.91205, 60, 263.95811
3151, -7.4519493, 60, 265.99897
3152, -29.053341, 60, 250.52692
3153, -23.601629, 60, 256.013
3154, -36.034377, 60, 233.70149
3155, -34.040438, 60, 241.17427
3156, 1196.1657, 60, -76.665122
3157, 1180.9257, 60, -76.665122
3158, 1160.4686, 60, -79.877012
3159, 1145.7086, 60, -79.877012
3160, 1171.8744, 60, -96.542134
3161, 1120.6221, 60, -76.810853
3162, 1105.5949, 60, -72.775893
3163, 1088.7895, 60, -52.740391
3164, 1077.8516, 60, -41.80255
3165, 1074.611, 60, -24.123687
3166, 1070.576, 60, -9.0964881
3167, 1067.6442, 60, 9.7590741
3168, 1071.6321, 60, 24.704627
3169, 1084.0247, 60, 45.051177
3170, 1095.0913, 60, 56.117745
3171, 1112.0349, 60, 69.313497
3172, 1126.9804, 60, 73.301376
3173, 1147.3726, 60, 80.396783
3174, 1163.3626, 60, 80.396783
3175, 1181.0062, 60, 75.368173
3176, 1195.0162, 60, 75.368173
3177, 1172.3888, 60, 95.764956
3178, 1213.6356, 60, 75.013285
3179, 1228.5811, 60, 71.025406
3180, 1248.7872, 60, 57.599168
3181, 1259.7593, 60, 46.695743
3182, 1266.6183, 60, 23.969875
3183, 1270.7004, 60, 8.9554269
3184, 1270.6204, 60, -9.3082052
3185, 1266.6795, 60, -24.266213
3186, 1260.2231, 60, -43.535115
3187, 1249.3542, 60, -54.541464
3188, 1233.4011, 60, -71.558513
3189, 1218.2111, 60, -75.688404
3190, 794.66991, 60, -127.83591
3191, 817.9229, 60, -83.22539
3192, 952.43044, 60, 117.16726
3193, 985.09765, 60, -82.110434
3194, 1010.9554, 60, -120.61827
3195, 1047.3421, 60, -119.29643
3196, 1001.2792, 60, -65.672683
3197, 655.32305, 60, 149.62272
3198, 536.66289, 60, -161.70645
3199, 982.17016, 60, 124.74617
3200, 506.58329, 60, -153.73098
3201, 471.2478, 60, -167.27424
3202, -14.28259, 60, -291.07498
3203, 0.44299789, 60, -291.51208
3204, -74.59069, 60, -272.8945
3205, -53.952303, 60, -278.04089
3206, -149.78667, 60, -242.079
3207, -132.80843, 60, -251.9449
3208, -199.62498, 60, -205.31146
3209, -187.67166, 60, -216.49229
3210, -240.69824, 60, -152.45124
3211, -230.83476, 60, -166.85514
3212, -270.56295, 60, -79.566327
3213, -263.62061, 60, -100.24699
3214, -286.14502, 60, 20.690291
3215, -286.75639, 60, 5.4252871
3216, -282.96434, 60, 58.685395
3217, -286.52069, 60, 37.162428
3218, -242.93928, 60, 141.86527
3219, -254.31663, 60, 120.12668
3220, -214.87207, 60, 196.20471
3221, -223.85383, 60, 185.93724
3222, -190.32484, 60, 215.46296
3223, -201.86041, 60, 204.63347
3224, -127.90587, 60, 253.24266
3225, -147.9148, 60, 242.09761
3226, -7.1691327, 60, 286.99914
3227, -22.427519, 60, 286.24034
3228, 22.725685, 60, 286.50285
3229, 6.9264079, 60, 287.35721
3230, 1141.5745, 60, -125.1317
3231, 1175.7086, 60, -124.87701
3232, -257.77971, 60, -67.86067
3233, 1025.187, 60, -55.152312
3234, 739.1842, 60, -133.29052
3235, 668.28826, 60, -100.0016
3236, 701.7101, 60, -136.94181
3237, 743.94183, 60, -92.491745
3238, 1029.9167, 60, 122.7381
3239, 417.37321, 60, -176.23928
3240, 199.83386, 60, -226.68811
3241, 245.97894, 60, -216.6708
3242, 82.326971, 60, -261.12688
3243, 106.06972, 60, -255.23194
3244, 1246.631, 60, 112.36535
3245, 1213.6356, 60, 120.01328
3246, 1329.0453, 60, -20.162238
3247, 1330.3839, 60, 11.380136
3248, 1311.0716, 60, -69.648658
3249, 1325.5687, 60, -41.085762
3250, 1249.9312, 60, -113.65042
3251, 1276.2988, 60, -93.131166
3252, 1218.2111, 60, -120.6884
3253, 195.14443, 60, 167.76595
3254, 172.84666, 60, 213.41984
3255, 138.49904, 60, 221.44615
3256, 485.70513, 60, 165.5804
3257, 377.86818, 60, 177.17426
3258, 315.23847, 60, 188.89738
3259, 432.34289, 60, 174.15358
3260, 704.48714, 60, 143.9052
3261, 876.28613, 60, 105.27373
3262, 870.09532, 60, 140.62223
3263, 833.79065, 60, 143.39964
3264, 177.74104, 60, -92.505423
3265, 1177.3726, 60, 125.39678
3266, 1142.6695, 60, 125.66003
3267, 129.72174, 60, -155.53412
3268, 80.761601, 60, -178.79169
3269, 55.199624, 60, -163.4658
3270, -160.293, 60, -77.086808
3271, -170.1967, 60, -39.649647
3272, -172.17545, 60, 37.838848
3273, -161.87872, 60, 74.444479
3274, -70.64939, 60, 158.1211
3275, 60.984097, 60, 176.72003
3276, 121.83562, 60, 173.454
3277, 185.91457, 60, 114.94787
3278, 208.50497, 60, 9.6468992
3279, 727.52172, 60, 9.5561741
3280, 705.4212, 60, 80.998581
3281, -230.41273, 60, -134.50746
3282, 415.57768, 60, -1.2224109
3283, 390.99042, 60, 30.370054
3284, 391.6246, 60, -34.276227
3285, 422.26811, 60, 97.339273
3286, 420.82032, 60, -98.621316
3287, 273.2481, 60, -168.66166
3288, 690.25811, 60, -77.962625
3289, 1021.0997, 60, 3.5096866
3290, 1010.2615, 60, 61.882052
3291, 831.01998, 60, 105.18727
3292, 853.8867, 60, 99.221516
3293, 792.18048, 60, 62.282877
3294, 777.67809, 60, 3.677458
3295, 1156.68, 14.97, 60
3296, 1155.99, 44.97, 60
3297, 1172.67, 30, 60
3298, 19.362615, 60, -189.70161
3299, 801.68978, 60, -66.838556
3300, 34.654697, 60, -209.26062
3301, 43.590502, 60, -214.23574
3302, 36.437934, 60, -199.4104
3303, 42.022149, 60, -232.99028
3304, 780.79806, 60, -58.11233
3305, -1.1118583, 60, -187.1294
3306, -8.8437318, 60, -178.72537
3307, 1.4147623, 60, -177.64518
3308, -21.125018, 60, -194.26329
3309, -35.73061, 60, -209.75919
3310, -41.204389, 60, -229.76171
3311, -36.348895, 60, -249.00839
3312, -21.361598, 60, -262.71855
3313, -2.0110944, 60, -268.3462
3314, 18.484135, 60, -264.2744
3315, 34.649188, 60, -251.2873
3316, -133.70557, 60, -190.25678
3317, -121.27077, 60, -175.21281
3318, -120.46644, 60, -149.46061
3319, -117.7704, 60, -139.87022
3320, -135.39244, 60, -128.1647
3321, -154.28306, 60, -120.18657
3322, -174.37245, 60, -122.03696
3323, -191.68655, 60, -133.32835
3324, -201.82584, 60, -151.52057
3325, -201.74136, 60, -173.08511
3326, -190.88745, 60, -193.50329
3327, -171.5042, 60, -203.38231
3328, -150.49279, 60, -200.24935
3329, -228.05809, 60, -41.496553
3330, -206.7852, 60, -35.454079
3331, -193.07089, 60, -20.993935
3332, -187.00817, 60, -2.9072459
3333, -189.04594, 60, 18.255587
3334, -203.73783, 60, 38.168343
3335, -225.6723, 60, 44.132373
3336, -246.83763, 60, 37.083846
3337, -265.13912, 60, 23.289086
3338, -273.51352, 60, -1.5322359
3339, -264.5448, 60, -23.962586
3340, -247.6488, 60, -36.134657
3341, -192.7305, 60, 130.64016
3342, -170.1478, 60, 118.00479
3343, -146.92581, 60, 120.64266
3344, -130.16179, 60, 135.06787
3345, -121.78729, 60, 152.32201
3346, -121.15581, 60, 173.15212
3347, -131.82533, 60, 190.81312
3348, -150.71895, 60, 200.74787
3349, -173.88707, 60, 203.0458
3350, -192.0662, 60, 191.02321
3351, -200.66799, 60, 172.10777
3352, -203.57345, 60, 151.57567
3353, -43.535595, 60, 227.61237
3354, -37.70162, 60, 206.13649
3355, -20.866178, 60, 191.7282
3356, -0.10911157, 60, 186.6416
3357, 21.006021, 60, 191.49082
3358, 37.897739, 60, 207.30427
3359, 43.160156, 60, 229.82642
3360, 36.139744, 60, 250.66032
3361, 22.165808, 60, 267.14369
3362, -0.61986375, 60, 274.35659
3363, -23.404983, 60, 266.05341
3364, -37.081658, 60, 248.75563
3365, 1084.4388, 60, -73.586204
3366, 1126.3307, 60, -96.687865
3367, 1064.3927, 60, -35.871839
3368, 1058.2202, 60, 0.66258606
3369, 1067.6811, 60, 39.864698
3370, 1097.0173, 60, 73.407
3371, 1134.353, 60, 93.698159
3372, 1247.4772, 60, 76.600332
3373, 1208.6518, 60, 90.381458
3374, 1274.5422, 60, 40.448227
3375, 1281.3211, 60, -0.54127356
3376, 1274.7847, 60, -38.073808
3377, 1252.3753, 60, -74.359759
3378, 1214.3768, 60, -92.353525
3379, -228.44269, 60, 141.15942
3380, -43.082395, 60, -269.37315
3381, -111.07479, 60, -238.71357
3382, -220.76768, 60, -163.88037
3383, -243.46651, 60, -101.75819
3384, -243.54732, 60, 101.48067
3385, -218.84907, 60, 171.8973
3386, -147.57127, 60, 229.19138
3387, -264.51382, 60, 63.341942
3388, -148.45442, 60, -229.32666
3389, 719.46695, 60, -63.196349
3390, 117.21646, 60, -221.52727
3391, 286.35069, 60, 154.17518
3392, -46.946535, 60, -154.00796
3393, -65.093525, 60, -166.2001
3394, -29.500041, 60, -157.85021
3395, -73.049339, 60, -251.40743
3396, -109.74924, 60, 238.90301
3397, 721.78908, 60, 108.59284
3398, -286.73925, 60, -10.232569
3399, 179.96773, 60, -200.27931
3400, 389.23603, 60, 134.5143
3401, -25.365934, 60, -167.82618
3402, -17.486878, 60, -280.6229
3403, -173.6926, 60, -213.24813
3404, -226.61275, 60, -85.13885
3405, -219.54589, 60, -102.30291
3406, -285.73232, 60, -26.022857
3407, -273.90633, 60, 30.597757
3408, -176.00857, 60, 213.02204
3409, -27.148972, 60, 275.1995
3410, -34.861086, 60, 287.44132
3411, -56.348695, 60, 283.67723
3412, 1035.7477, 60, 25.04403
3413, 1040.6405, 60, -2.0161955
3414, 384.86635, 60, -139.73486
3415, 367.7934, 60, 100.35996
3416, 1309.8978, 60, 18.559447
3417, 1327.3606, 60, 32.504327
3418, 1294.0997, 60, 76.240835
3419, 1266.837, 60, 98.939116
3420, 1313.6954, 60, 64.495607
3421, 1196.1657, 60, -121.66512
3422, 228.71019, 60, 117.9973
3423, 765.24452, 60, 69.644827
3424, 782.249, 60, 97.188581
3425, 811.95563, 60, 128.03899
3426, 1100.5119, 60, 127.00613
3427, 1062.9736, 60, 127.88388
3428, 150.78881, 60, -175.34773
3429, 122.55808, 60, -191.75642
3430, -177.57629, 60, -90.356019
3431, -185.40884, 60, -72.414358
3432, -170.58156, 60, -1.2032249
3433, 366.13986, 60, -107.22117
3434, 1037.373, 60, 98.339971
3435, -35.83855, 60, 267.25438
3436, -44.952252, 60, 257.62621
3437, -48.69624, 60, 266.77231
3438, -49.939348, 60, 248.27356
3439, 1287.2789, 60, 51.428866
3440, 187.1314, 60, -164.05702
3441, 748.87663, 60, 42.050566
3442, 738.94515, 60, 76.956269
3443, 96.1494, 60, -201.71367
3444, 51.379603, 60, -229.78984
3445, 49.518021, 60, -239.77544
3446, 36.918744, 60, -273.59568
3447, 44.968281, 60, -281.97773
3448, 753.82108, 60, 2.2447317
3449, 1122.2774, 60, 118.56463
3450, 43.896471, 60, -178.13422
3451, 39.063905, 60, -155.95946
3452, 21.641897, 60, -159.91125
3453, 10.72182, 60, -169.93451
3454, -82.286399, 60, 166.50194
3455, -66.800521, 60, 173.72036
3456, 239.63981, 60, 23.900786
3457, 228.66445, 60, -31.631527
3458, -221.57301, 60, -119.55429
3459, -215.5861, 60, -135.1395
3460, -51.616621, 60, -234.59722
3461, -50.993768, 60, -224.0369
3462, -125.19463, 60, -194.33785
3463, -132.13381, 60, -200.85176
3464, -158.55425, 60, -106.64327
3465, -148.18925, 60, -108.57177
3466, -222.28578, 60, -52.006085
3467, -233.93207, 60, -52.043765
3468, -112.38984, 60, -175.92797
3469, -117.88545, 60, -184.45803
3470, -234.80593, 60, 51.355487
3471, -223.55055, 60, 53.772719
3472, -252.36521, 60, -46.330721
3473, -260.30963, 60, -40.931144
3474, -192.53255, 60, 116.99409
3475, -202.6069, 60, 125.65552
3476, -196.31456, 60, -40.941302
3477, -205.94117, 60, -46.946095
3478, -145.52698, 60, 112.0946
3479, -134.81334, 60, 118.70642
3480, -118.06616, 60, 135.37941
3481, -124.11654, 60, 127.56603
3482, -113.62825, 60, 156.45299
3483, -115.95237, 60, 147.01224
3484, -112.39715, 60, 178.43504
3485, -110.70451, 60, 167.04568
3486, -133.51927, 60, 202.07654
3487, -124.54239, 60, 195.80489
3488, -208.7519, 60, 174.33642
3489, -205.07785, 60, 182.59445
3490, -53.380713, 60, 224.41849
3491, -51.913873, 60, 236.2091
3492, -168.12347, 60, 104.80836
3493, -180.63182, 60, 108.78232
3494, 30.77224, 60, 183.9761
3495, 20.879547, 60, 178.7633
3496, 49.198953, 60, 206.60888
3497, 42.199928, 60, 196.00822
3498, 52.590604, 60, 242.48457
3499, 54.327212, 60, 230.56308
3500, 40.611342, 60, 260.55368
3501, 45.895147, 60, 251.64128
3502, -41.220783, 60, 193.90203
3503, -48.521599, 60, 203.58731
3504, 63.192595, 60, -278.53239
3505, 71.673412, 60, -248.89003
3506, -109.90712, 60, 139.51039
3507, 202.82739, 60, -120.57164
3508, 232.00631, 60, -145.50323
3509, 288.94409, 60, -125.17628
3510, 222.61595, 60, -73.951635
3511, -214.43921, 60, 161.41062
3512, -213.67062, 60, 149.13654
3513, 18.453694, 60, -178.33854
3514, -163.45465, 60, 93.272427
3515, -152.97063, 60, 102.4949
3516, 1062.8129, 60, -90.187896
3517, 1046.0075, 60, -70.152393
3518, 35.361814, 60, 288.17496
3519, 26.111806, 60, 276.38675
3520, 42.073454, 60, 183.2807
3521, 56.297044, 60, 284.41404
3522, 34.801937, 60, 268.81579
3523, 44.55734, 60, 269.79675
3524, 55.707256, 60, -251.43527
3525, 74.841632, 60, -234.02976
3526, -115.307, 60, -222.23944
3527, -94.190568, 60, -225.75932
3528, -177.03157, 60, 76.757947
3529, 756.94105, 60, -59.545056
3530, -239.34657, 60, -73.573715
3531, -215.42594, 60, -74.118433
3532, -269.26121, 60, -34.15865
3533, -223.13619, 60, 102.09653
3534, -234.3345, 60, 80.22985
3535, 1046.8129, 60, -38.550621
3536, 253.7508, 60, -59.697748
3537, -59.784466, 60, 245.07968
3538, -200.15011, 60, 193.25186
3539, 1030.147, 60, 46.64941
3540, 1049.6878, 60, 41.123528
3541, 57.143581, 60, 216.94219
3542, 61.445769, 60, 205.64613
3543, 66.574028, 60, 229.60034
3544, -246.5929, 60, -56.840252
3545, -162.75719, 60, 214.38722
3546, -211.81514, 60, -57.493308
3547, -58.562099, 60, 213.42323
3548, -66.940377, 60, 222.01996
3549, -62.081262, 60, 201.18878
3550, 76.234748, 60, 244.56933
3551, 68.801906, 60, 266.99523
3552, 1195.0162, 60, 120.36817
3553, -244.29135, 60, 47.432971
3554, -242.1696, 60, 57.073317
3555, 1292.2519, 60, -76.114117
3556, 1092.1954, 60, 95.044251
3557, 107.98585, 60, 230.18362
3558, -48.983784, 60, -250.45172
3559, -58.773164, 60, -244.72692
3560, 79.051117, 60, 230.94843
3561, -194.68951, 60, 69.387854
3562, -196.26543, 60, 88.215802
3563, -194.93628, 60, 52.239802
3564, -214.17015, 60, 63.697657
3565, -254.20131, 60, 42.801676
3566, -43.505438, 60, -259.13809
3567, 358.5824, 60, 50.072971
3568, 325.55032, 60, 87.247997
3569, -20.938555, 60, -272.95361
3570, -30.447505, 60, -267.92982
3571, -97.223139, 60, -155.75755
3572, -96.687914, 60, -134.66136
3573, -75.682175, 60, -235.55293
3574, -140.85815, 60, 100.55866
3575, -123.12112, 60, 104.50059
3576, -99.078089, 60, 139.39013
3577, -41.952408, 60, 169.98497
3578, -25.870461, 60, 161.42832
3579, 13.895628, 60, 170.0623
3580, -207.84485, 60, -195.77813
3581, -190.50822, 60, 103.79767
3582, 44.805393, 60, -189.49728
3583, 51.664731, 60, -195.55368
3584, 756.32318, 60, -28.816934
3585, 8.1745791, 60, -281.98836
3586, -204.71925, 60, -102.93495
3587, -94.040561, 60, 161.61564
3588, -90.191692, 60, 177.2149
3589, -57.640313, 60, -181.9003
3590, -78.31908, 60, -181.68918
3591, 75.419989, 60, -208.56254
3592, -53.602136, 60, 178.34618
3593, -40.391033, 60, 182.99163
3594, 1186.68, 14.97, 60
3595, 1185.99, 44.97, 60
3596, -104.86959, 60, 161.73591
3597, -96.964298, 60, 151.02295
3598, -84.644327, 60, -203.33729
3599, -92.09754, 60, -187.63709
3600, -109.6073, 60, -134.73084
3601, -65.239146, 60, 186.72702
3602, -120.57617, 60, -106.64176
3603, -140.70416, 60, -104.38111
3604, 326.47946, 60, -99.687439
3605, 362.43343, 60, -58.573898
3606, -162.52922, 60, -213.59382
3607, -118.70372, 60, -129.07494
3608, -119.74424, 60, -118.83466
3609, -112.22457, 60, -156.10444
3610, -127.90734, 60, -123.97404
3611, -100.77373, 60, -166.33587
3612, -97.388406, 60, -175.58108
3613, -45.666796, 60, -213.17768
3614, -40.81587, 60, -203.73548
3615, -183.81836, 60, -116.60969
3616, -174.09397, 60, -112.83081
3617, -203.01132, 60, -130.5136
3618, -195.42161, 60, -123.00109
3619, -142.39143, 60, -205.68532
3620, -152.23945, 60, -209.16398
3621, -154.42786, 60, -219.02979
3622, -133.88048, 60, -209.76638
3623, -180.62552, 60, -16.346365
3624, -184.71322, 60, -24.801716
3625, -180.977, 60, 23.767389
3626, -176.96421, 60, 12.235895
3627, -103.71365, 60, -197.22919
3628, -152.37838, 60, 209.57537
3629, -142.46165, 60, 205.91227
3630, -135.1787, 60, 210.90404
3631, -154.49988, 60, 219.55162
3632, 28.669673, 60, -181.99094
3633, 4.1294085, 60, 177.57702
3634, -7.0930307, 60, 177.94059
3635, 62.106449, 60, 276.15193
3636, -15.797908, 60, 171.75321
3637, -20.036428, 60, 180.81779
3638, -56.079028, 60, -218.01319
3639, 57.062202, 60, 252.37793
3640, 1062.0804, 60, 61.470077
3641, 1075.2518, 60, 81.848499
3642, 1057.2585, 60, 83.107328
3643, -80.412109, 60, -219.81142
3644, -112.05945, 60, 194.90649
3645, -101.60815, 60, 188.80005
3646, 1043.5723, 60, -20.871758
3647, -214.40061, 60, -156.14647
3648, -210.74247, 60, -169.93417
3649, -208.10842, 60, -180.81902
3650, -217.37898, 60, 117.6784
3651, -208.16616, 60, 96.427579
3652, 348.74734, 60, 17.258096
3653, -138.16466, 60, -224.89682
3654, -211.85104, 60, -145.46677
3655, -217.57693, 60, 131.32447
3656, -137.19247, 60, 224.37953
3657, -253.20033, 60, 66.382395
3658, -262.96851, 60, 50.110347
3659, -168.00016, 60, -101.21601
3660, 1297.1611, 60, 7.5788072
3661, 1294.1379, 60, 28.702998
3662, 277.12082, 60, 101.3571
3663, -128.25009, 60, 220.54381
3664, -127.90704, 60, -220.06325
3665, -113.75339, 60, 206.16991
3666, -243.71491, 60, 70.304912
3667, -184.25719, 60, 43.85854
3668, -116.31369, 60, -195.053
3669, -265.5148, 60, 39.761223
3670, -199.08133, 60, -69.058443
3671, -181.79804, 60, -55.789233
3672, -178.6505, 60, -6.7150264
3673, -66.135934, 60, -213.1309
3674, -195.14313, 60, -113.79494
3675, 25.218131, 60, -270.24727
3676, 40.838423, 60, -262.94714
3677, -28.776759, 60, -190.68286
3678, -19.022093, 60, -184.62916
3679, -89.853989, 60, 193.68635
3680, 1024.2016, 60, 77.961549
3681, 285.23766, 60, -76.52901
3682, -183.86919, 60, -36.293732
3683, -75.496808, 60, 238.40097
3684, -73.522283, 60, 250.46543
3685, 72.411784, 60, 188.75215
3686, -80.678194, 60, 227.40571
3687, -111.02283, 60, -207.10901
3688, 80.356413, 60, 199.08546
3689, 46.349801, 60, -254.63571
3690, -65.462397, 60, 274.04906
3691, -37.981679, 60, -194.7964
3692, -35.878754, 60, -185.16227
3693, 14.564456, 60, -274.92294
3694, -47.917865, 60, -198.21489
3695, -136.43296, 60, -117.92441
3696, -122.71771, 60, 119.01797
3697, -29.571055, 60, 185.54081
3698, -86.696105, 60, 208.1481
3699, -95.252536, 60, 224.52911
3700, -115.76715, 60, 219.6454
3701, 1084.6658, 44.999534, -23.197475
3702, 1088.7815, 29.996667, -31.251712
3703, 1093.1777, 44.997132, -37.519012
3704, 1093.1243, 44.997158, 37.452159
3705, 1088.7712, 29.996697, 31.234809
3706, 1084.6185, 44.999539, 23.08429
3707, -75.279647, 60, 196.56295
3708, -223.30378, 60, 70.920771
3709, 351.9642, 60, -26.742493
3710, 319.55618, 60, -7.0395754
3711, 1080.5393, 44.999539, 8.0261852
3712, 1080, 29.999073, -0.028427865
3713, 1080.5431, 44.999534, -8.0543566
3714, 1309.4444, 60, -23.488268
3715, 1297.0811, 60, -10.684825
3716, -60.808962, 60, -202.27168
3717, 267.90982, 60, 51.070113
3718, 90.017132, 60, 214.05445
3719, 1124.5316, 44.97, 57.97178
3720, 1118.189, 29.967158, 55.895266
3721, 1104.5161, 44.997158, 48.382768
3722, 1118.181, 29.967132, -55.892129
3723, 1104.4332, 14.997132, -48.321855
3724, 1124.4405, 14.97, -57.947411
3725, 51.816433, 60, -210.49575
3726, 52.109663, 60, -219.26469
3727, -16.495473, 60, -175.14494
3728, -57.97477, 60, -193.3326
3729, -44.749215, 60, -177.84351
3730, 59.605535, 60, -226.04985
3731, 1104.4332, 44.997132, -48.321855
3732, 1124.4405, 44.97, -57.947411
3733, 291.28616, 60, -34.208902
3734, 288.06931, 60, 9.7916865
3735, 60.183892, 60, -200.58263
3736, 1293.6044, 60, -31.608349
3737, 1287.148, 60, -50.877251
3738, 75.571691, 60, -223.50461
3739, 1.4405826, 60, -276.01549
3740, -8.4009712, 60, -275.41163
3741, -35.544296, 60, -173.72997
3742, -193.11601, 60, -96.543554
3743, 145.49371, 317.1, -36.490843
3744, 118.02149, 332.35972, -92.579304
3745, 92.379086, 332.35972, -118.17827
3746, 145.63259, 116.1, -35.932544
3747, 143.4578, 208.72761, -43.816206
3748, 143.4578, 259.72761, -43.816206
3749, 60.739634, 83.410694, -137.15209
3750, 80.654099, 83.410694, -126.47101
3751, -7.2172834, 73.652833, -149.82627
3752, 7.8559778, 73.652833, -149.79414
3753, -77.831635, 79.012827, -128.22729
3754, -60.284953, 79.012827, -137.35256
3755, -129.55528, 74.088284, -75.600454
3756, -118.77122, 74.088284, -91.615487
3757, -149.24265, 76.05, -15.054257
3758, -146.12854, 193.75386, -33.859257
3759, -146.12854, 158.65386, -33.859257
3760, -146.45902, 329.4, -32.399915
3761, -56.464031, 330, -138.96695
3762, -111.01075, 318.20486, -100.8792
3763, -132.41995, 318.20486, -70.462451
3764, 14.09783, 274.15503, -149.33603
3765, -5.9395171, 274.15503, -149.88236
3766, 124.51096, 99.661587, -83.648203
3767, 140.92364, 155.76159, -51.386061
3768, 119.76702, 192.2892, -90.309804
3769, 103.09402, 99.661587, -108.95698
3770, -148.20187, 98.959049, -23.156114
3771, -145.12961, 82.909049, -37.912993
3772, -144.51383, 287.60486, -40.196445
3773, 39.710421, 338.66557, -144.64813
3774, 39.710421, 308.66557, -144.64813
3775, 71.726725, 338.66557, -131.73943
3776, -148.20187, 124.00905, -23.156114
3777, -138.7909, 82.909049, -56.895407
3778, 24.118776, 80.513004, -148.04825
3779, 41.57924, 80.513004, -144.12206
3780, -41.043942, 77.152014, -144.27541
3781, -23.569024, 77.152014, -148.13676
3782, -107.12383, 78.184376, -104.99755
3783, -93.488421, 78.184376, -117.30266
3784, -144.51383, 244.40486, -40.196445
3785, 52.186801, 103.9237, -140.62908
3786, -131.71049, 225.75872, -71.779858
3787, -139.14983, 140.46291, -56.01183
3788, -135.12101, 96.997333, -65.133046
3789, 41.642657, 282.00211, -144.10374
3790, 35.903954, 256.15714, -145.63964
3791, -19.695554, 248.64078, -148.70133
3792, -33.584146, 274.48575, -146.19201
3793, -53.019711, 293.44051, -140.31718
3794, -86.357113, 323.44051, -122.64766
3795, 128.48878, 302.62761, -77.399188
3796, -16.246829, 90.804847, -149.11754
3797, -86.958953, 97.197203, -122.22169
3798, -114.07639, 92.27266, -97.399063
3799, -52.082472, 96.164841, -140.66775
3800, 16.49917, 94.165837, -149.08983
3801, 80.569081, 311.0253, -126.52519
3802, 94.485597, 123.07228, -116.50095
3803, 59.903859, 142.57577, -137.51919
3804, 84.804578, 158.82666, -123.72624
3805, -17.62088, 114.30949, -148.96142
3806, -1.2146198, 110.81031, -149.99508
3807, 82.255123, 284.36183, -125.43562
3808, 60.548784, 290.66769, -137.23646
3809, -97.486532, 123.19157, -114.00165
3810, -82.216651, 124.02002, -125.46084
3811, 15.123983, 117.67048, -149.2356
3812, -123.42023, 107.30459, -85.249319
3813, -112.49195, 111.40069, -99.224797
3814, -108.61124, 138.2235, -103.45819
3815, -134.05382, 116.12536, -67.302112
3816, -60.030627, 116.51308, -137.4639
3817, -40.776835, 114.65227, -144.35113
3818, -128.81141, 150.77017, -76.861043
3819, -65.696825, 267.92626, -134.84779
3820, -12.663151, 218.78891, -149.46453
3821, -40.114207, 219.11962, -144.53667
3822, -108.48915, 281.64537, -103.58622
3823, 91.266678, 211.79269, -119.03946
3824, -26.098903, 134.65773, -147.71204
3825, -72.020844, 142.50744, -131.57887
3826, -73.034578, 233.33601, -131.01889
3827, -90.059598, 252.29077, -119.95528
3828, 28.680778, 213.32011, -147.23251
3829, 7.9988414, 183.79895, -149.78658
3830, -66.776501, 203.48413, -134.31641
3831, -114.03747, 247.05512, -97.444626
3832, -118.17645, 196.40412, -92.381417
3833, 55.579398, 221.16719, -139.32312
3834, 113.17885, 274.98733, -98.440586
3835, -94.805676, 183.85745, -116.24063
3836, -116.77725, 162.56105, -94.143896
3837, 40.701404, 139.67808, -144.37242
3838, 23.375254, 156.32255, -148.16746
3839, -64.753981, 169.64107, -135.30307
3840, -18.022161, 161.79135, -148.9134
3841, 97.023942, 254.62972, -114.39561
3842, -41.16561, 162.13413, -144.24075
3843, 0, 300, -121.27712
3844, 0, 300, 121.27712
3845, 20, 330, 121.27712
3846, 20, 330, -121.27712
3847, 1124.5316, 14.97, 57.97178
3848, 1104.5161, 14.997158, 48.382768
3849, -54.677767, 360, -107.18711
3850, -65.186986, 360, 103.80696
3851, -45.590069, 360, 112.96456
3852, -100.03622, 360, 69.898454
3853, -86.478459, 360, 86.671597
3854, -118.17366, 360, 26.469924
3855, -113.32834, 360, 47.485965
3856, -123, 360, -9.184851e-15
3857, -116.00164, 360, -31.635066
3858, -111.12767, 360, -52.709817
3859, -97.547099, 360, -69.464494
3860, -74.223229, 360, -98.069757
3861, 52.307357, 360, 108.87486
3862, 71.852819, 360, 99.757512
3863, 71.790936, 360, -99.777935
3864, 52.039981, 360, -109.05668
3865, 109.33451, 360, -56.293089
3866, 118.21172, 360, -20.898503
3867, 95.769706, 360, 73.033824
3868, 95.873744, 360, -73.062619
3869, 109.35028, 360, 56.279147
3870, 118.12603, 360, 21.074752
3871, 123, 360, -1.2858791e-15
3872, -20, 330, -121.27712
3873, 1093.1243, 14.997158, 37.452159
3874, 1084.6185, 14.999539, 23.08429
3875, 1080.5393, 14.999539, 8.0261852
3876, 1080.5431, 14.999534, -8.0543566
3877, -20, 330, 121.27712
3878, -7.7319657, 280.45193, -95.688122
3879, 12.372715, 280.45193, -95.199348
3880, 66.402432, 337.78279, -69.330491
3881, 80.244952, 337.78279, -52.694854
3882, 93.575237, 334.44, -21.440034
3883, 87.195262, 197.05859, -40.162001
3884, 87.195262, 149.53859, -40.162001
3885, 88.782284, 99.775171, -36.519941
3886, 88.782284, 61.975171, -36.519941
3887, 65.361255, 120.07376, -70.312917
3888, 92.754848, 26.82, -24.749509
3889, -92.715857, 30.42, -24.895178
3890, -61.531694, 22.583402, -73.68752
3891, -78.448884, 22.583402, -55.333286
3892, 34.80454, 24.601548, -89.468676
3893, 10.412439, 24.601548, -95.433648
3894, -90.114453, 53.003402, -33.096605
3895, -93.531274, 331.92, -21.631013
3896, -92.633118, 241.88187, -25.201297
3897, -92.633118, 280.58187, -25.201297
3898, -89.886258, 79.585172, -33.711432
3899, -89.886258, 112.88517, -33.711432
3900, -72.753302, 71.748573, -62.633513
3901, -89.714947, 306.29679, -34.164723
3902, -79.709747, 334.37679, -53.500992
3903, -65.652609, 334.37679, -70.040952
3904, -77.599791, 283.03866, -56.517895
3905, 89.986665, 312.22279, -33.442489
3906, 76.366006, 35.155171, -58.174162
3907, 40.819524, 330, -86.889392
3908, 48.90454, 307.78279, -82.6096
3909, 1084.6658, 14.999534, -23.197475
3910, 1093.1777, 14.997132, -37.519012
3911, 85.5674, 281.87866, -43.522639
3912, 85.5674, 239.57866, -43.522639
3913, -39.68506, 27.359323, -87.413363
3914, -53.988823, 49.942725, -79.380142
3915, -15.807749, 27.359323, -94.689572
3916, -5.1430506, 51.960871, -95.862136
3917, -87.913984, 151.78796, -38.563343
3918, -87.913984, 201.28796, -38.563343
3919, -40.582874, 330, -87.000175
3920, 31.939857, 257.89059, -90.530909
3921, 39.127571, 277.43866, -87.664321
3922, -30.073002, 277.19246, -91.168057
3923, -18.072226, 257.64439, -94.283586
3924, -48.238942, 304.37679, -83.000027
3925, -74.707294, 216.72984, -60.289471
3926, 59.51162, 212.35725, -75.328395
3927, -68.773265, 137.23314, -66.979385
3928, -56.962734, 281.56924, -77.273844
3929, 58.548104, 35.155171, -76.079692
3930, -41.638023, 107.25018, -86.500145
3931, -36.858642, 146.15297, -88.642205
3932, -53.445293, 76.524495, -79.747104
3933, 8.4569421, 82.686553, -95.626775
3934, -17.742523, 85.444328, -94.346186
3935, -64.266693, 255.85433, -71.31474
3936, 46.479078, 59.756718, -83.998187
3937, -53.068203, 215.26042, -79.998536
3938, 31.753216, 230.92397, -90.596541
3939, 35.252491, 188.4039, -89.293123
3940, 65.046038, 285.22145, -70.604624
3941, 4.4674192, 233.93724, -95.895997
3942, 34.993449, 93.240176, -89.394958
3943, -18.266495, 230.67776, -94.246141
3944, -32.898197, 191.55327, -90.187076
3945, 31.264803, 143.0036, -90.76625
3946, 0.019752945, 161.57031, -95.999998
3947, 2.4311787, 268.82123, 95.969211
3948, -17.615752, 268.82123, 94.369938
3949, -40.642065, 330, 86.972539
3950, -67.717112, 338.72598, 68.04699
3951, -81.273512, 338.72598, 51.09419
3952, -50.643151, 308.72598, 81.555327
3953, -93.545972, 331.92, 21.567363
3954, -90.590622, 283.13678, 31.770098
3955, -90.590622, 244.43678, 31.770098
3956, -91.182285, 201.85511, 30.029832
3957, -91.182285, 152.35511, 30.029832
3958, -76.106346, 219.85189, 58.513452
3959, -91.561836, 110.36011, 28.851865
3960, -91.561836, 77.060108, 28.851865
3961, -77.941675, 135.27522, 56.045475
3962, -92.754848, 30.42, 24.749509
3963, 92.715857, 26.82, 24.895178
3964, 60.690709, 20.579012, 74.381704
3965, 77.903508, 20.579012, 56.098515
3966, -41.6529, 30.435322, 86.492982
3967, -17.94635, 30.435322, 94.307627
3968, 89.786177, 47.399012, 33.977086
3969, 93.531274, 334.44, 21.631013
3970, 89.201166, 157.03748, 35.484531
3971, 89.201166, 204.55748, 35.484531
3972, 89.559092, 76.415039, 34.571216
3973, 89.559092, 114.21504, 34.571216
3974, 70.437834, 142.01251, 65.226617
3975, 71.526452, 70.17405, 64.030982
3976, 90.584456, 298.63386, 31.787676
3977, 81.0925, 324.19386, 51.380993
3978, 67.476294, 324.19386, 68.285795
3979, 40.582874, 330, 87.000175
3980, 50.410322, 294.19386, 81.699446
3981, -81.028486, 46.640108, 51.481884
3982, -90.674756, 310.64598, 31.52917
3983, 38.319944, 27.571708, 88.020349
3984, 52.08607, 48.15072, 80.641437
3985, 51.550639, 77.166746, 80.984762
3986, 14.183169, 27.571708, 94.946499
3987, -3.5148988, 58.00703, 95.935632
3988, 90.584456, 256.33386, 31.787676
3989, 72.419462, 236.61134, 63.019216
3990, -48.341229, 250.03801, 82.940494
3991, -50.426174, 281.21678, 81.689662
3992, 29.099769, 272.1306, 91.483351
3993, 11.818702, 240.95183, 95.269713
3994, -49.920341, 207.45635, 81.999753
3995, -75.131227, 289.94276, 59.760344
3996, -59.134198, 158.6165, 75.62504
3997, -60.1042, 116.62149, 74.85643
3998, -8.5309368, 87.933013, 95.620202
3999, 23.504237, 85.069399, 93.078197
4000, -26.160097, 188.80262, 92.366928
4001, -62.657734, 30.435322, 72.732443
4002, 47.2416, 107.09273, 83.571713
4003, 1184.76, 14.97, -60
4004, 1184.76, 44.97, -60
4005, 1169.52, 30, -60
4006, 1154.76, 14.97, -60
4007, 1154.76, 44.97, -60
4008, 46.385193, 149.91517, 84.050068
4009, 28.883428, 215.53663, 91.551885
4010, 2.2043074, 212.22727, 95.97469
4011, 19.078535, 150.90372, 94.085118
4012, 46.811231, 185.82351, 83.813535
4013, -35.863222, 100.41671, 89.049589
4014, -59.359662, 77.075429, 75.448197
4015, 58.169599, 266.32446, 76.369482
4016, 54.98105, 214.54807, 78.696151
4017, -8.9927753, 163.38742, 95.577874
4018, -9.4778095, 127.47908, 95.530996
4019, -147.5671, 329.4, 26.906326
4020, -136.63348, 335.55733, 61.897422
4021, -123.80338, 335.55733, 84.691937
4022, -105.93232, 328.30575, 106.19955
4023, -84.809324, 328.30575, 123.72299
4024, -116.94539, 303.86309, 93.934959
4025, -149.17005, 76.05, 15.757377
4026, -148.22209, 99.170307, 23.026338
4027, -148.22209, 124.22031, 23.026338
4028, -144.98308, 83.120307, 38.469543
4029, -147.31281, 156.65896, 28.265482
4030, -147.31281, 191.75896, 28.265482
4031, -137.93177, 83.120307, 58.947668
4032, -119.28566, 75.760009, 90.944659
4033, -128.54504, 75.760009, 77.305711
4034, -68.122671, 77.683041, 133.6387
4035, -82.769437, 77.683041, 125.09684
4036, 0.53880886, 81.579506, 149.99903
4037, -14.752567, 81.579506, 149.27278
4038, 74.354569, 83.49835, 130.27432
4039, 51.51387, 83.49835, 140.87697
4040, 143.54725, 241.74637, 43.522247
4041, 143.54725, 190.74637, 43.522247
4042, 145.546, 317.1, 36.281722
4043, 98.976398, 324.88567, 112.71057
4044, 123.05365, 324.88567, 85.777612
4045, -10.798641, 280.63092, 149.61079
4046, 9.2458826, 280.63092, 149.71477
4047, -145.52026, 304.95733, 36.384787
4048, 140.1475, 281.98567, 53.466597
4049, 118.60535, 249.53204, 91.830116
4050, -141.22774, 138.67927, 50.544288
4051, -145.80415, 229.87382, 35.229968
4052, -145.80415, 273.07382, 35.229968
4053, -136.55351, 209.23278, 62.073666
4054, -96.529578, 77.589366, 114.81307
4055, -108.21979, 77.589366, 103.86759
4056, -32.299841, 79.594335, 146.48113
4057, -50.847688, 79.594335, 141.11879
4058, 33.488082, 77.609136, 146.21405
4059, 17.241148, 77.609136, 149.00585
4060, 119.09972, 88.431615, 91.18803
4061, 96.158643, 88.431615, 115.12391
4062, 147.7089, 91.772528, 26.116664
4063, 135.98273, 91.772528, 63.314271
4064, 45.12073, 101.10749, 143.05286
4065, 41.005901, 334.70389, 144.28623
4066, 73.187574, 334.70389, 130.93349
4067, 24.608518, 250.96711, 147.96763
4068, 35.196996, 270.33619, 145.81211
4069, 41.005901, 304.70389, 144.28623
4070, -132.90415, 279.23116, 69.544847
4071, 126.47184, 120.20414, 80.652792
4072, 10.270285, 99.188642, 149.64799
4073, 85.706883, 111.92996, 123.10293
4074, -33.894593, 281.39805, 146.12035
4075, -24.823399, 262.02897, 147.93174
4076, -24.135186, 101.17384, 148.04558
4077, -115.02993, 93.349375, 96.27105
4078, -90.284627, 95.272406, 119.786
4079, -59.200398, 97.277376, 137.82348
4080, 88.489336, 299.58956, 121.11828
4081, 55.640993, 275.04008, 139.29853
4082, -37.823618, 337.4008, 145.15293
4083, -37.823618, 307.4008, 145.15293
4084, 83.569822, 265.22186, 124.56358
4085, 92.086644, 224.98256, 118.40629
4086, -63.247026, 337.4008, 136.01402
4087, -135.33973, 98.880317, 64.677338
4088, -117.78224, 179.98882, 92.883499
4089, -113.23798, 218.10368, 98.37256
4090, -84.730917, 112.25599, 123.7767
4091, -98.327258, 112.16231, 113.27732
4092, -112.67637, 114.74275, 99.015336
4093, -123.1641, 112.9134, 85.618949
4094, -108.04612, 131.72634, 104.04824
4095, 91.06528, 141.49347, 119.1936
4096, 68.623464, 136.5602, 133.38223
4097, -133.74168, 120.2737, 67.920271
4098, -29.981313, 235.51032, 146.9732
4099, -6.800404, 234.74319, 149.84577
4100, 25.240453, 121.7558, 147.86115
4101, 8.615836, 125.72617, 149.75235
4102, 43.537038, 127.64502, 143.54277
4103, 147.7089, 147.87253, 26.116664
4104, -117.68642, 271.97958, 93.00487
4105, 133.77701, 166.4189, 67.850657
4106, -51.309243, 288.79885, 140.95163
4107, 115.96634, 163.07799, 95.140994
4108, -131.25026, 152.71235, 72.617959
4109, -16.479728, 126.05463, 149.09198
4110, -33.993506, 124.06946, 146.09737
4111, -1.4302572, 148.62179, 149.99318
4112, -92.075341, 242.73561, 118.41508
4113, 19.419115, 224.44846, 148.73768
4114, 10.843783, 32.901837, 255.97164
4115, 17.069091, 29.64226, 252.67075
4116, 9.9047302, 26.727628, 256.31777
4117, 62.487772, 203.39804, 136.36451
4118, 102.32403, 187.70822, 109.68041
4119, -77.343959, 305.70655, 128.52203
4120, -69.709596, 114.06936, 132.81782
4121, -78.699514, 130.95926, 127.69646
4122, -52.524934, 115.98065, 140.50314
4123, -105.15293, 161.58325, 106.97131
4124, 49.840277, 157.20852, 141.47773
4125, 5.6227332, 38.25323, 257.46837
4126, 13.246388, 41.167862, 254.91715
4127, -45.2202, 140.86144, 143.02144
4128, -67.703029, 225.82791, 133.85178
4129, -51.065179, 198.54213, 141.04023
4130, -73.849146, 279.7038, 130.56149
4131, 36.965305, 194.48286, 145.37388
4132, -57.826614, 168.90498, 138.4055
4133, -19.253312, 178.58739, 148.75923
4134, -16.619868, 37.89656, 252.97559
4135, -19.34522, 30.802067, 250.92951
4136, -22.352297, 38.253207, 248.00937
4137, -5.1681448, 30.216312, 257.55149
4138, -9.9018371, 37.886657, 256.31879
4139, -1.8642712, 37.657549, 257.94202
4140, -75.169023, 160.81618, 129.80608
4141, -89.801636, 159.00281, 120.14852
4142, 5.8256023, 178.25894, 149.88683
4143, 685.89482, 30, 31.118972
4144, 630.1088, 30, 103.86016
4145, 654.85281, 30, 84.852814
4146, 601.11897, 30, 115.89482
4147, 539.06311, 30, 115.94356
4148, 570, 30, 120
4149, 485.14719, 30, 84.852814
4150, 510.21779, 30, 104.04848
4151, 454.05644, 30, 30.936887
4152, 465.95152, 30, 59.782213
4153, 673.86016, 30, 60.108795
4154, 454.10518, 30, -31.118972
4155, 485.28058, 30, -84.985995
4156, 466.13984, 30, -60.108795
4157, 570.37699, 30, -119.99941
4158, 539.24528, 30, -115.99201
4159, 601.30098, 30, -115.8458
4160, 654.986, 30, -84.719423
4161, 630.1088, 30, -103.86016
4162, 685.94356, 30, -30.936887
4163, 510.21779, 30, -104.04848
4164, 674.04848, 30, -59.782213
4165, 986.92112, 30, 23.339229
4166, 944.83666, 30, 78.036363
4167, 963.53957, 30, 63.739497
4168, 923.06604, 30, 86.994009
4169, 876.52426, 30, 86.884347
4170, 899.71726, 30, 89.999556
4171, 836.2605, 30, 63.539567
4172, 854.9184, 30, 77.89512
4173, 813.04233, 30, 23.202665
4174, 821.96364, 30, 44.836659
4175, 977.89512, 30, 45.081596
4176, 813.04233, 30, -23.202665
4177, 836.0612, 30, -63.33901
4178, 821.96364, 30, -44.836659
4179, 875.97882, 30, -86.735131
4180, 854.42987, 30, -77.610328
4181, 945.81373, 30, -77.466782
4182, 923.33923, 30, -86.921116
4183, 964.13747, 30, -63.137828
4184, 986.99401, 30, -23.066044
4185, 899.15178, 30, -89.996003
4186, 978.17684, 30, -44.59128
4187, 28.998003, 7.5, -220.31132
4188, 19.30405, 7.0098323, -205.03582
4189, 24.517646, 7.0098323, -210.71171
4190, -11.147434, 7.742689, -200.14799
4191, -3.2155995, 7.742689, -198.17283
4192, -29.010045, 7.5, -220.35688
4193, 29.29261, 53.816415, -221.52366
4194, 29.29261, 46.286415, -221.52366
4195, 29.541463, 33.045502, -222.77487
4196, 29.541463, 40.545502, -222.77487
4197, 23.311856, 54.574185, -209.11727
4198, 17.655723, 54.574185, -203.74561
4199, 11.768073, 53.085121, -200.40448
4200, 4.0225759, 53.085121, -198.27091
4201, 14.502188, 47.659306, -201.73812
4202, -3.6278829, 52.752005, -198.22017
4203, -11.182708, 52.752005, -200.16213
4204, 0.68062911, 45.837126, -198.00772
4205, -17.716678, 52.723918, -203.7901
4206, -23.359281, 52.723918, -209.17597
4207, -13.927741, 45.475923, -201.429
4208, -27.014678, 52.500117, -214.95365
4209, -29.456031, 52.500117, -222.31297
4210, -29.456031, 44.970117, -222.31297
4211, -24.592244, 45.224035, -210.81799
4212, 22.010806, 24.756364, 248.38442
4213, 22.678498, 30.930573, 247.63888
4214, -29.456031, 37.470117, -222.31297
4215, -29.389344, 24.355847, -221.97784
4216, -29.389344, 16.885847, -221.97784
4217, -26.885268, 9.385847, -214.68901
4218, 23.236261, 38.222558, 246.97567
4219, 26.796919, 33.336661, 241.48796
4220, 28.129565, 14.509832, -217.57275
4221, 12.444204, 7.809365, -200.70271
4222, 16.679331, 14.819197, -203.06408
4223, 4.8466416, 7.809365, -198.39409
4224, 1.457118, 15.552054, -198.03541
4225, -23.326801, 8.0557437, -209.13574
4226, -17.750989, 8.0557437, -203.81524
4227, -24.337288, 17.441591, -210.45872
4228, 29.388205, 19.837924, -221.97228
4229, 29.388205, 27.307924, -221.97228
4230, 26.632763, 53.816415, -214.19073
4231, -13.680737, 15.798433, -201.30098
4232, 27.889166, 30.413426, -216.94584
4233, -2.3111458, 23.22337, -198.08916
4234, 5.7407018, 23.290046, -198.55438
4235, -26.219541, 25.013874, -213.4214
4236, -22.400162, 23.683771, -208.04423
4237, -28.612328, 30.598027, -218.98143
4238, 24.104893, 48.3906, -210.14071
4239, 25.460828, 19.347756, -212.13349
4240, 21.119211, 23.530904, -206.69322
4241, 24.114074, 28.858996, -210.15311
4242, 14.637119, 24.330437, -201.81308
4243, 5.153017, 38.565801, -198.44587
4244, -2.4899459, 38.232685, -198.10351
4245, -16.830979, 38.109302, -203.16619
4246, -10.170275, 38.137389, -199.77651
4247, -22.465783, 38.351945, -208.11813
4248, -26.383891, 38.128144, -213.72098
4249, -16.749076, 23.441128, -203.11088
4250, -10.001341, 23.128073, -199.7162
4251, -5.840359, 30.866064, -198.57399
4252, -19.541499, 31.013411, -205.23754
4253, 24.591172, 34.596574, -210.81645
4254, 27.716895, 41.891917, -216.52073
4255, 11.23848, 32.001753, -200.1846
4256, 14.112581, 39.606193, -201.52671
4257, 19.688923, 41.095257, -205.36493
4258, 23.838388, 40.337487, -209.78651
4259, -28.973705, 7.5, -235.77974
4260, -19.08855, 7.0136797, -251.14362
4261, -24.437249, 7.0136797, -245.40175
4262, 10.844277, 7.6372034, -255.97144
4263, 3.2664559, 7.6372034, -257.82164
4264, 28.98589, 7.5, -235.73422
4265, -29.293605, 53.835449, -234.47184
4266, -29.293605, 46.305449, -234.47184
4267, -29.548673, 33.067948, -233.1842
4268, -29.548673, 40.567948, -233.1842
4269, -23.282075, 54.59923, -246.91943
4270, -17.579321, 54.59923, -252.30982
4271, -11.675447, 53.182665, -255.63483
4272, -4.1563106, 53.182665, -257.71069
4273, -14.496478, 47.781895, -254.26504
4274, 3.5402853, 52.693044, -257.79037
4275, 11.144555, 52.693044, -255.85317
4276, -0.62112426, 45.875709, -257.99357
4277, 18.016815, 52.391371, -251.98738
4278, 23.620984, 52.391371, -246.49457
4279, 14.387085, 45.084415, -254.32512
4280, 27.173949, 54.661421, -240.71127
4281, 29.53243, 54.661421, -233.27594
4282, 29.53243, 47.131421, -233.27594
4283, 25.088891, 47.052792, -244.44833
4284, 29.46998, 40.706933, -233.61429
4285, 29.46998, 33.206933, -233.61429
4286, 28.023315, 42.898354, -238.70952
4287, 29.387446, 25.482647, -234.03142
4288, 29.387446, 18.012647, -234.03142
4289, 26.839097, 10.512647, -241.40384
4290, 27.739509, 28.74958, -239.42452
4291, -28.113959, 14.51368, -238.46925
4292, -4.667053, 7.6367298, -257.63475
4293, -12.192419, 7.6367298, -255.41067
4294, 23.12385, 7.8836307, -247.1125
4295, 17.376443, 7.8836307, -252.45525
4296, 24.198637, 18.396278, -245.73206
4297, -29.394778, 19.849003, -233.99559
4298, -29.394778, 27.319003, -233.99559
4299, -16.60834, 14.650409, -252.98325
4300, -26.613167, 53.835449, -241.847
4301, -1.5067548, 15.273933, -257.96214
4302, 13.398208, 15.520834, -254.84191
4303, -27.916479, 30.446952, -238.985
4304, -24.107551, 48.434678, -245.8557
4305, 16.245739, 23.048273, -253.22055
4306, 9.5603516, 22.801846, -256.43589
4307, -24.274493, 28.893986, -245.62807
4308, -24.750523, 34.642931, -244.95322
4309, 25.346855, 25.354798, -244.04796
4310, 21.073632, 22.725782, -249.35186
4311, 17.920809, 30.006793, -252.05919
4312, 25.571765, 33.079084, -243.68709
4313, -25.454475, 19.362683, -243.8767
4314, -5.0630423, 38.58834, -257.56967
4315, 2.627516, 38.098719, -257.88471
4316, 9.8656997, 37.857686, -256.3314
4317, 16.906735, 37.556013, -252.7823
4318, 24.8986, 40.628304, -244.73498
4319, -21.25635, 23.558663, -249.16997
4320, 5.5543254, 30.570317, -257.48134
4321, 2.3058768, 23.042878, -257.91125
4322, -23.985213, 40.380432, -246.0197
4323, -19.868155, 41.144213, -250.47791
4324, -14.809635, 24.181713, -254.08974
4325, -27.734528, 41.933397, -239.4366
4326, -5.6175206, 23.042405, -257.46936
4327, 21.630678, 37.233522, -248.78735
4328, -14.31701, 39.727648, -254.36329
4329, -11.380737, 31.950658, -255.7575
4330, -135.23173, 7.5, -176.20674
4331, -131.35297, 7.0232566, -158.40255
4332, -131.63615, 7.0232566, -166.19783
4333, -148.92971, 7.6795458, -133.85357
4334, -142.28982, 7.6795458, -137.94729
4335, -176.12502, 7.5, -135.18478
4336, -135.92141, 53.828268, -177.34374
4337, -135.92141, 46.298268, -177.34374
4338, -136.64008, 33.062942, -178.41949
4339, -136.64008, 40.562942, -178.41949
4340, -131.37698, 54.584174, -164.28195
4341, -131.60397, 54.584174, -156.43808
4342, -133.41484, 53.0662, -149.9574
4343, -137.28683, 53.0662, -143.13204
4344, -132.39749, 47.650374, -152.89911
4345, -142.66183, 52.672657, -137.64957
4346, -149.3659, 52.672657, -133.66182
4347, -139.52619, 45.738857, -140.49926
4348, -156.97234, 52.390993, -131.52263
4349, -164.81902, 52.390993, -131.43697
4350, -152.7121, 45.06365, -132.45214
4351, -171.43958, 54.658757, -133.01455
4352, -178.3658, 54.658757, -136.6026
4353, -178.3658, 47.128757, -136.6026
4354, -167.29653, 47.049749, -131.84212
4355, -178.07082, 40.701976, -136.39976
4356, -178.07082, 33.201976, -136.39976
4357, -173.43592, 42.890733, -133.81999
4358, -177.69819, 25.478074, -136.15083
4359, -177.69819, 18.008074, -136.15083
4360, -170.54381, 10.508074, -132.70591
4361, -172.69533, 28.74005, -133.50167
4362, -133.93901, 14.523257, -173.69947
4363, -136.86803, 7.7992395, -143.69993
4364, -133.17434, 7.7992395, -150.5704
4365, -163.82918, 7.894153, -131.334
4366, -156.03607, 7.894153, -131.67169
4367, -165.66249, 18.402227, -131.55105
4368, -136.17751, 19.848244, -177.73872
4369, -136.17751, 27.318244, -177.73872
4370, -131.79606, 14.822496, -155.37129
4371, -132.60569, 53.828268, -170.23152
4372, -138.85192, 15.478785, -141.22901
4373, -151.53433, 15.573699, -132.82702
4374, -133.68563, 30.441186, -173.12999
4375, -131.54198, 48.412442, -165.60149
4376, -154.68826, 23.070405, -131.94012
4377, -147.68928, 22.855798, -134.44517
4378, -131.5592, 28.87477, -165.71659
4379, -131.6937, 34.619469, -166.52858
4380, -167.69409, 25.353345, -131.92716
4381, -160.87709, 22.739424, -131.22231
4382, -168.13092, 33.077247, -132.02713
4383, -131.98801, 19.3715, -167.96352
4384, -136.57483, 38.511258, -144.11484
4385, -141.7237, 38.117716, -138.41946
4386, -148.03151, 37.84891, -134.27494
4387, -155.52416, 37.567245, -131.76609
4388, -166.94553, 40.622969, -131.77171
4389, -131.22055, 23.549783, -161.11097
4390, -156.71911, 30.021523, -131.55995
4391, -144.01181, 30.62131, -136.64665
4392, -141.43478, 23.124604, -138.66971
4393, -131.4923, 40.354795, -165.25063
4394, -131.28989, 41.110701, -159.17888
4395, -132.32726, 24.325766, -153.14635
4396, -133.50215, 41.92121, -172.69649
4397, -136.23137, 23.244298, -144.62062
4398, -161.73091, 37.236263, -131.22469
4399, -132.49779, 39.592726, -152.55924
4400, -133.51628, 31.971585, -149.71015
4401, -187.30261, 7.5, -146.39754
4402, -191.05943, 7.0334427, -164.32337
4403, -190.85075, 7.0334427, -156.52574
4404, -173.35355, 7.7037121, -188.65728
4405, -179.98009, 7.7037121, -184.63128
4406, -146.19315, 7.5, -187.18539
4407, -186.51927, 53.829667, -145.09694
4408, -186.51927, 46.299667, -145.09694
4409, -185.80376, 33.064159, -144.0257
4410, -185.80376, 40.564159, -144.0257
4411, -191.06341, 54.58788, -158.15578
4412, -190.8372, 54.58788, -165.99967
4413, -189.03367, 53.066307, -172.46397
4414, -185.19479, 53.066307, -179.25437
4415, -190.0498, 47.654187, -169.51868
4416, -179.8605, 52.66899, -184.72661
4417, -173.12707, 52.66899, -188.75632
4418, -182.96816, 45.735297, -181.88511
4419, -165.67498, 52.312456, -190.88777
4420, -157.82908, 52.312456, -191.02805
4421, -169.98311, 44.981446, -189.91205
4422, -150.8572, 54.691857, -189.37359
4423, -143.9494, 54.691857, -185.75021
4424, -143.9494, 47.161857, -185.75021
4425, -155.19865, 47.004313, -190.60979
4426, -144.34202, 40.61251, -186.022
4427, -144.34202, 33.11251, -186.022
4428, -148.83432, 42.834367, -188.54408
4429, -144.61787, 25.638451, -186.2075
4430, -144.61787, 18.168451, -186.2075
4431, -151.62097, 10.668451, -189.64308
4432, -149.57644, 28.810961, -188.86848
4433, -188.54236, 14.533443, -148.83054
4434, -185.40775, 7.8024873, -178.96773
4435, -189.16553, 7.8024873, -172.13211
4436, -158.62035, 8.0013939, -191.10747
4437, -166.41336, 8.0013939, -190.76747
4438, -156.77905, 18.669845, -190.88977
4439, -186.27632, 19.849863, -144.72192
4440, -186.27632, 27.319863, -144.72192
4441, -190.60696, 14.83593, -167.25583
4442, -189.835, 53.829667, -152.20915
4443, -183.50658, 15.506199, -181.30326
4444, -171.01915, 15.705106, -189.57495
4445, -188.7667, 30.444023, -149.33766
4446, -190.89828, 48.417548, -156.83624
4447, -167.91757, 23.192502, -190.46325
4448, -174.74077, 22.89482, -188.0009
4449, -190.88703, 28.884625, -156.76077
4450, -190.75029, 34.628921, -155.9305
4451, -154.60777, 25.524711, -190.4825
4452, -161.72096, 22.857654, -191.21617
4453, -165.74748, 30.047368, -190.8768
4454, -154.28394, 32.99877, -190.40744
4455, -190.47987, 19.383306, -154.59613
4456, -185.87704, 38.519424, -178.30974
4457, -180.75929, 38.122107, -183.98501
4458, -174.4774, 37.860098, -188.13225
4459, -167.14012, 37.503564, -190.63049
4460, -155.6672, 40.454966, -190.70191
4461, -191.21953, 23.568204, -161.44106
4462, -178.44347, 30.644225, -185.78382
4463, -180.98167, 23.156829, -183.79223
4464, -190.95016, 40.364429, -157.20312
4465, -191.15011, 41.122642, -163.27201
4466, -190.08493, 24.337249, -169.39567
4467, -188.94063, 41.923827, -149.74926
4468, -186.15757, 23.255604, -177.89772
4469, -160.92572, 37.168716, -191.2189
4470, -189.94511, 39.601068, -169.87412
4471, -188.91887, 31.987879, -172.74387
4472, -220.22026, 7.5, -28.973705
4473, -204.88523, 7.0230414, -19.12348
4474, -210.59677, 7.0230414, -24.436194
4475, -199.98481, 7.6789811, 10.730743
4476, -198.16536, 7.6789811, 3.1454807
4477, -220.17475, 7.5, 28.961449
4478, -221.51124, 53.827982, -29.289861
4479, -221.51124, 46.297982, -29.289861
4480, -222.77986, 33.062647, -29.542345
4481, -222.77986, 40.562647, -29.542345
4482, -209.06133, 54.583609, -23.266428
4483, -203.67565, 54.583609, -17.559221
4484, -200.37323, 53.06506, -11.694503
4485, -198.28566, 53.06506, -4.1301297
4486, -201.73298, 47.648669, -14.492881
4487, -198.2107, 52.671841, 3.5492857
4488, -200.13272, 52.671841, 11.109209
4489, -198.0077, 45.736901, -0.67986011
4490, -203.99967, 52.391067, 17.999562
4491, -209.48845, 52.391067, 23.60768
4492, -201.64634, 45.062908, 14.334731
4493, -215.28308, 54.659508, 27.171306
4494, -222.71792, 54.659508, 29.531333
4495, -222.71792, 47.129508, 29.531333
4496, -211.52842, 47.050575, 25.073634
4497, -222.3693, 40.703864, 29.46685
4498, -222.3693, 33.203864, 29.46685
4499, -217.26905, 42.893372, 28.015117
4500, -221.93748, 25.480975, 29.381045
4501, -221.93748, 18.010975, 29.381045
4502, -214.48355, 10.510975, 26.782563
4503, -216.53069, 28.744839, 27.721019
4504, -217.52904, 14.523041, -28.113325
4505, -198.38135, 7.7961204, -4.7682105
4506, -200.63112, 7.7961204, -12.285939
4507, -208.76885, 7.8954668, 23.025263
4508, -203.48285, 7.8954668, 17.288991
4509, -210.194, 18.406442, 24.144279
4510, -221.97072, 19.8479, -29.387885
4511, -221.97072, 27.3179, -29.387885
4512, -203.0464, 14.819162, -16.652859
4513, -214.13763, 53.827982, -26.605163
4514, -198.04467, 15.475102, -1.6364328
4515, -201.09826, 15.574448, 13.277671
4516, -216.94907, 30.440547, -27.890445
4517, -210.11046, 48.411592, -24.082452
4518, -202.70033, 23.071284, 16.122249
4519, -199.51316, 22.854798, 9.4074297
4520, -210.20161, 28.873391, -24.149894
4521, -210.87138, 34.618139, -24.629461
4522, -211.88643, 25.357602, 25.305197
4523, -206.57382, 22.742094, 20.998069
4524, -212.25953, 33.080491, 25.538941
4525, -212.09258, 19.370941, -25.435293
4526, -198.47502, 38.50806, -5.3174684
4527, -198.0924, 38.114841, 2.3527757
4528, -199.62784, 37.847659, 9.7478504
4529, -203.15688, 37.566884, 16.817235
4530, -211.23326, 40.624931, 24.87723
4531, -206.70397, 23.548533, -21.130048
4532, -203.86183, 30.022444, 17.81429
4533, -198.46035, 30.618817, 5.2353403
4534, -198.06637, 23.121981, 1.9945002
4535, -209.8256, 40.353474, -23.868206
4536, -205.3892, 41.109101, -19.716784
4537, -201.85058, 24.321612, -14.704003
4538, -216.51365, 41.92063, -27.713965
4539, -198.58689, 23.23912, -5.9050076
4540, -207.16401, 37.237694, 21.583828
4541, -201.56264, 39.590551, -14.179779
4542, -200.2657, 31.968491, -11.437154
4543, -235.77974, 7.5, 28.973705
4544, -251.20092, 7.0122838, 19.01887
4545, -245.43683, 7.0122838, 24.41223
4546, -255.92414, 7.766084, -10.965515
4547, -257.81249, 7.766084, -3.3489666
4548, -235.73422, 7.5, -28.98589
4549, -234.49266, 53.821837, 29.288997
4550, -234.49266, 46.291837, 29.288997
4551, -233.23415, 33.04904, 29.539865
4552, -233.23415, 40.54904, 29.539865
4553, -246.93844, 54.58266, 23.266622
4554, -252.32417, 54.58266, 17.559469
4555, -255.62164, 53.074072, 11.706612
4556, -257.70598, 53.074072, 4.189822
4557, -254.26052, 47.656732, 14.504662
4558, -257.80335, 52.75994, -3.429377
4559, -255.89446, 52.75994, -11.040804
4560, -257.9902, 45.834012, 0.76658992
4561, -252.29321, 52.731763, -17.602273
4562, -246.89744, 52.731763, -23.299933
4563, -254.61995, 45.491704, -13.83395
4564, -241.10845, 52.503684, -26.984596
4565, -233.70851, 52.503684, -29.451874
4566, -233.70851, 44.973684, -29.451874
4567, -245.23866, 45.235448, -24.552569
4568, -26.325105, 38.061102, 242.38711
4569, -28.586034, 30.549357, 237.10158
4570, -29.449189, 37.451745, 233.72235
4571, -233.70851, 37.473684, -29.451874
4572, -234.05794, 24.353969, -29.38199
4573, -234.05794, 16.883969, -29.38199
4574, -241.42806, 9.3839685, -26.826989
4575, 19.017767, 42.364594, 251.20182
4576, 14.522763, 47.715986, 254.25051
4577, -238.50962, 14.512284, 28.098894
4578, -255.44299, 7.8205113, 12.119507
4579, -253.02509, 14.832795, 16.545233
4580, -257.63981, 7.8205113, 4.6348185
4581, -257.96772, 15.586595, 1.3912441
4582, -246.98349, 8.0546036, -23.229877
4583, -252.33061, 8.0546036, -17.550539
4584, -245.61901, 17.438572, -24.281072
4585, -234.05034, 19.838623, 29.383557
4586, -234.05034, 27.308623, 29.383557
4587, -241.86591, 53.821837, 26.603319
4588, -254.72932, 15.820688, -13.621429
4589, -239.08414, 30.417663, 27.877264
4590, -257.91183, 23.256613, -2.2983928
4591, -257.45847, 23.31104, 5.6743801
4592, -242.64412, 25.01588, -26.183006
4593, -248.02876, 23.686515, -22.334927
4594, -237.05527, 30.601911, -28.600735
4595, -245.89249, 48.404497, 24.080255
4596, -243.96059, 19.350907, 25.401957
4597, -249.37992, 23.540862, 21.045163
4598, -245.87844, 28.867202, 24.090689
4599, -254.23039, 24.34909, 14.559075
4600, -257.54843, 38.564601, 5.185578
4601, -257.90174, 38.250469, -2.4260475
4602, -252.87906, 38.129581, -16.76402
4603, -256.25457, 38.157758, -10.083617
4604, -247.94601, 38.363674, -22.408854
4605, -242.33208, 38.135596, -26.355103
4606, -252.9409, 23.452421, -16.671885
4607, -256.29735, 23.163901, -9.9629229
4608, -257.43361, 30.888346, -5.8019707
4609, -250.80932, 31.029729, -19.486793
4610, -245.20432, 34.607618, 24.576641
4611, -239.50318, 41.900877, 27.706982
4612, -255.81937, 32.019107, 11.228657
4613, -254.46798, 39.60265, 14.122532
4614, -250.66184, 41.111238, 19.658105
4615, -246.23962, 40.350415, 23.818401
4616, -176.20674, 7.5, 135.23173
4617, -158.39415, 7.0229359, 131.35377
4618, -166.18951, 7.0229359, 131.63475
4619, -133.79147, 7.6779888, 149.06894
4620, -137.85139, 7.6779888, 142.40833
4621, -135.25531, 7.5, 176.24754
4622, -177.34382, 53.827965, 135.92146
4623, -177.34382, 46.297965, 135.92146
4624, -178.41871, 33.062405, 136.63953
4625, -178.41871, 40.562405, 136.63953
4626, -164.28315, 54.583829, 131.3771
4627, -156.43928, 54.583829, 131.60377
4628, -149.96414, 53.061155, 133.41211
4629, -143.17548, 53.061155, 137.25406
4630, -152.90727, 47.644984, 132.39514
4631, -137.67826, 52.67289, 142.62545
4632, -133.66152, 52.67289, 149.36662
4633, -140.50396, 45.734045, 139.5217
4634, -131.52144, 52.39121, 156.98065
4635, -131.43798, 52.39121, 164.82735
4636, -132.44954, 45.0641, 152.7209
4637, -133.01561, 54.660281, 171.44252
4638, -136.60439, 54.660281, 178.36836
4639, -136.60439, 47.130281, 178.36836
4640, -131.84446, 47.051491, 167.3078
4641, -136.40594, 40.706062, 178.07992
4642, -136.40594, 33.206062, 178.07992
4643, -133.82574, 42.896342, 173.44882
4644, -136.16846, 25.484197, 177.72498
4645, -136.16846, 18.014197, 177.72498
4646, -132.76029, 10.514197, 170.70851
4647, -133.51818, 28.750258, 172.73512
4648, -173.69179, 14.522936, 133.9355
4649, -143.59743, 7.792537, 136.94211
4650, -150.54028, 7.792537, 133.18579
4651, -131.35253, 7.894222, 164.03344
4652, -131.6448, 7.894222, 156.19174
4653, -131.56538, 18.408419, 165.75721
4654, -177.73665, 19.847625, 136.17615
4655, -177.73665, 27.317625, 136.17615
4656, -155.33141, 14.815473, 131.80402
4657, -170.23162, 53.827965, 132.60572
4658, -141.16168, 15.470526, 138.91228
4659, -132.78789, 15.572211, 151.6498
4660, -173.12684, 30.44003, 133.68427
4661, -165.60279, 48.411794, 131.54217
4662, -131.91905, 23.069203, 154.78341
4663, -134.40383, 22.85297, 147.77139
4664, -165.7101, 28.872158, 131.55821
4665, -166.52362, 34.616938, 131.69281
4666, -131.9405, 25.361665, 167.75416
4667, -131.22139, 22.74169, 160.97027
4668, -131.55054, 30.022449, 156.78159
4669, -132.03648, 33.083529, 168.17029
4670, -167.95288, 19.370561, 131.98555
4671, -144.10623, 38.501421, 136.5808
4672, -138.40741, 38.113156, 141.73779
4673, -134.25979, 37.847871, 148.06252
4674, -131.75812, 37.566191, 155.56552
4675, -131.77542, 40.627272, 166.96457
4676, -161.09844, 23.547469, 131.22059
4677, -136.61715, 30.615247, 144.05402
4678, -138.61968, 23.118255, 141.49194
4679, -165.24668, 40.352498, 131.49176
4680, -159.17601, 41.108362, 131.29008
4681, -153.11139, 24.31707, 132.33705
4682, -172.6957, 41.92037, 133.50183
4683, -144.57901, 23.232803, 136.25906
4684, -131.22536, 37.238678, 161.76875
4685, -152.5623, 39.585689, 132.49687
4686, -149.68999, 31.964799, 133.52466
4687, -146.23395, 7.5, 187.20896
4688, -164.11587, 7.013102, 191.08029
4689, -156.27339, 7.013102, 190.80966
4690, -188.68945, 7.7648669, 173.28055
4691, -184.62222, 7.7648669, 179.99139
4692, -187.18539, 7.5, 146.19315
4693, -145.10003, 53.822068, 186.52124
4694, -145.10003, 46.292068, 186.52124
4695, -144.03215, 33.049349, 185.80827
4696, -144.03215, 40.549349, 185.80827
4697, -158.15787, 54.582936, 191.06362
4698, -166.00174, 54.582936, 190.83687
4699, -172.47035, 53.074463, 189.03109
4700, -179.25987, 53.074463, 185.19065
4701, -169.52732, 47.657399, 190.04732
4702, -184.7162, 52.759268, 179.87363
4703, -188.74967, 52.759268, 173.14244
4704, -181.87796, 45.833731, 182.97495
4705, -190.84428, 52.730413, 165.95559
4706, -191.05882, 52.730413, 158.11138
4707, -189.82277, 45.48968, 170.27027
4708, -189.57102, 52.502135, 151.41018
4709, -186.08353, 52.502135, 144.43279
4710, -186.08353, 44.972135, 144.43279
4711, -190.77223, 45.232547, 156.05448
4712, -16.546255, 23.186204, 253.02442
4713, -22.293282, 23.542851, 248.0751
4714, -186.08353, 37.472135, 144.43279
4715, -186.28394, 24.351276, 144.73349
4716, -186.28394, 16.881276, 144.73349
4717, -189.68713, 9.3812757, 151.75239
4718, -9.8487717, 22.696057, 256.33728
4719, -1.8081791, 22.46695, 257.94546
4720, -148.76938, 14.513102, 188.51455
4721, -171.98802, 7.8202759, 189.22137
4722, -167.17711, 14.833378, 190.62301
4723, -178.84291, 7.8202759, 185.49884
4724, -181.38761, 15.585143, 183.43029
4725, -191.07144, 8.0497968, 158.23499
4726, -190.82441, 8.0497968, 166.07825
4727, -190.85198, 17.431072, 156.53351
4728, -144.71758, 19.839229, 186.27346
4729, -144.71758, 27.309229, 186.27346
4730, -152.21265, 53.822068, 189.8361
4731, -189.73864, 15.814664, 170.532
4732, -149.34012, 30.418578, 188.76776
4733, -183.96808, 23.255023, 180.77899
4734, -178.0042, 23.310432, 186.08603
4735, -190.09381, 25.010914, 153.07646
4736, -191.17742, 23.679435, 159.61606
4737, -187.85134, 30.599638, 147.40767
4738, -156.84193, 48.405003, 190.89912
4739, -154.52556, 19.352331, 190.4638
4740, -161.43626, 23.54173, 191.21957
4741, -156.81732, 28.867857, 190.89548
4742, -169.44302, 24.348904, 190.07147
4743, -178.43144, 38.564619, 185.79224
4744, -184.06602, 38.249424, 180.6645
4745, -190.66294, 38.125988, 166.97652
4746, -188.32121, 38.154843, 174.0867
4747, -191.17052, 38.360051, 159.49199
4748, -189.99362, 38.131773, 152.72926
4749, -190.63885, 23.445372, 167.09842
4750, -188.25625, 23.160442, 174.22264
4751, -186.11899, 30.885731, 177.95527
4752, -191.12638, 31.025213, 163.59295
4753, -155.99968, 34.607977, 190.7626
4754, -149.75992, 41.901417, 188.94504
4755, -172.9318, 32.018784, 188.83994
4756, -169.94042, 39.603091, 189.92505
4757, -163.33633, 41.111564, 191.14563
4758, -157.26858, 40.350696, 190.95893
4759, -28.973705, 7.5, 220.22026
4760, -19.074846, 7.0221369, 204.84508
4761, -24.426943, 7.0221369, 210.58379
4762, 10.807769, 7.6781927, 200.01443
4763, 3.2275398, 7.6781927, 198.17412
4764, 28.98589, 7.5, 220.26578
4765, -29.289607, 53.827651, 221.51009
4766, -29.289607, 46.297651, 221.51009
4767, -29.54201, 33.062222, 222.77797
4768, -29.54201, 40.562222, 222.77797
4769, -23.264991, 54.583093, 209.05956
4770, -17.557375, 54.583093, 203.67432
4771, -11.690231, 53.063975, 200.37142
4772, -4.1255345, 53.063975, 198.28502
4773, -14.486826, 47.647068, 201.72964
4774, 3.5565433, 52.67082, 198.21156
4775, 11.115998, 52.67082, 200.13542
4776, -0.66791483, 45.734794, 198.00744
4777, 18.004969, 52.39071, 204.00373
4778, 23.61185, 52.39071, 209.49377
4779, 14.347087, 45.061529, 201.65306
4780, 27.172265, 54.660393, 215.28513
4781, 29.531731, 54.660393, 222.72015
4782, 29.531731, 47.130393, 222.72015
4783, 25.078586, 47.051103, 211.53596
4784, 29.468195, 40.70609, 222.37634
4785, 29.468195, 33.20609, 222.37634
4786, 28.018491, 42.896482, 217.27787
4787, 29.385159, 25.484191, 221.95745
4788, 29.385159, 18.014191, 221.95745
4789, 26.834017, 10.514191, 214.586
4790, 27.731544, 28.75028, 216.55616
4791, -28.107757, 14.522137, 217.5141
4792, -4.6921867, 7.7953111, 198.36922
4793, -12.215664, 7.7953111, 200.59968
4794, 23.110448, 7.8939943, 208.8713
4795, 17.359298, 7.8939943, 203.53258
4796, 24.179477, 18.408185, 210.24182
4797, -29.386932, 19.847161, 221.96608
4798, -29.386932, 27.317161, 221.96608
4799, -16.614741, 14.817448, 203.021
4800, -26.604621, 53.827651, 214.13659
4801, -1.5712611, 15.473504, 198.04118
4802, 13.344342, 15.572187, 201.13127
4803, -27.88799, 30.439383, 216.94287
4804, -24.080396, 48.410744, 210.1077
4805, 16.174109, 23.068246, 202.73346
4806, 9.4624335, 22.852445, 199.53138
4807, -24.143221, 28.872109, 210.19256
4808, -24.624645, 34.61717, 210.86446
4809, 25.326232, 25.361291, 211.91952
4810, 21.039316, 22.741095, 206.61432
4811, 17.847547, 30.021353, 203.88641
4812, 25.552565, 33.08319, 212.28165
4813, -25.424322, 19.369298, 212.07506
4814, -5.2964879, 38.505433, 198.47125
4815, 2.3766874, 38.112277, 198.09429
4816, 9.7760766, 37.845072, 199.63755
4817, 16.84149, 37.564962, 203.17332
4818, 24.885012, 40.6268, 211.24482
4819, -21.114107, 23.547085, 206.68816
4820, 5.2739533, 30.61571, 198.46721
4821, 2.0464614, 23.119651, 198.06988
4822, -23.863552, 40.3526, 209.81949
4823, -19.710163, 41.108041, 205.38342
4824, -14.67229, 24.320259, 201.83277
4825, -27.712779, 41.919873, 216.51079
4826, -5.8593706, 23.236769, 198.57777
4827, 21.601581, 37.237811, 207.18242
4828, -14.169954, 39.588923, 201.55738
4829, -11.415717, 31.966406, 200.25687
4830, 28.98589, 7.5, 235.73422
4831, 18.846173, 6.1255536, 251.34142
4832, 24.309803, 6.1255536, 245.57935
4833, -10.936726, 7.473347, 255.93543
4834, -3.3650654, 7.473347, 257.81067
4835, -28.998003, 7.5, 235.68868
4836, 28.973705, 52.47, 235.77974
4837, 29.285314, 35.284323, 234.50925
4838, 29.285314, 42.784323, 234.50925
4839, 23.319447, 54.456359, 246.87335
4840, 17.589213, 54.456359, 252.30267
4841, 11.605009, 53.259627, 255.66449
4842, 4.0339177, 53.259627, 257.72755
4843, -3.4677145, 52.663947, 257.79891
4844, -11.032872, 52.663947, 255.89759
4845, 0.75910471, 45.923574, 257.99039
4846, -17.610995, 52.673851, 252.28689
4847, -23.277018, 52.673851, 246.92566
4848, -13.752246, 45.337797, 254.66225
4849, -26.978436, 52.481745, 241.12113
4850, -29.449189, 52.481745, 233.72235
4851, -29.449189, 44.951745, 233.72235
4852, -24.523548, 45.155596, 245.27992
4853, -13.623634, 15.436841, 254.7282
4854, -29.380203, 24.330974, 234.0666
4855, -29.380203, 16.860974, 234.0666
4856, -26.844102, 9.3609737, 241.39381
4857, 28.020128, 13.625554, 238.71785
4858, 11.735649, 6.5670283, 255.60932
4859, 16.00681, 12.692582, 253.37286
4860, 4.2210544, 6.5670283, 257.70156
4861, 0.95703057, 14.040375, 257.98473
4862, -23.250997, 7.9634942, 246.95761
4863, -17.501153, 7.9634942, 252.36616
4864, 26.595458, 50.314323, 241.88098
4865, 24.120051, 44.770682, 245.83881
4866, -24.267812, 17.324468, 245.63727
4867, 29.085092, 20.522338, 235.35238
4868, 29.085092, 27.992338, 235.35238
4869, 5.7619667, 21.560631, 257.44146
4870, -26.154928, 24.94033, 242.69421
4871, 24.538877, 19.147892, 245.25814
4872, 12.470288, 18.301054, 255.28538
4873, 19.464054, 17.859579, 250.82872
4874, -162.58319, 52.390993, -124.74332
4875, -233.52966, 44.510948, -35.194265
4876, -239.44075, 42.725547, -41.848434
4877, -233.77764, 52.007263, -42.047619
4878, -245.11952, 43.221968, -34.481696
4879, -239.4564, 52.503684, -34.68088
4880, -245.3675, 50.718283, -41.335049
4881, 35.213529, 21.14601, -232.25373
4882, 40.000864, 25.327819, -229.86731
4883, 41.664361, 20.102757, -235.23379
4884, 34.787335, 19.181809, -225.61357
4885, 36.450832, 13.956747, -230.98006
4886, 41.238167, 18.138556, -228.59363
4887, -208.02284, 29.439667, -52.866556
4888, -214.68021, 21.117132, -42.767524
4889, -207.87918, 29.033167, -40.011488
4890, -203.83561, 22.497537, -53.396014
4891, -197.03458, 30.413572, -50.639978
4892, -203.69196, 22.091038, -40.540946
4893, -222.13135, 52.007263, -42.009938
4894, -227.92545, 52.007263, -36.280502
4895, -142.15869, 44.815575, -246.88105
4896, 26.456732, 192.65038, -118.8993
4897, 6.2216636, 227.64034, -122.84107
4898, 33.324872, 235.48742, -116.15943
4899, -252.23459, 34.97751, -51.976053
4900, -244.04242, 34.854003, -40.857013
4901, -245.24639, 28.394946, -51.6972
4902, -240.64473, 36.26649, -52.688622
4903, -232.45256, 36.142983, -41.569582
4904, -146.61219, 47.626687, -231.33236
4905, -156.57966, 32.442261, -243.01973
4906, -147.97005, 34.451736, -223.56659
4907, -133.54907, 46.825049, -227.42792
4908, -143.51655, 31.640624, -239.11529
4909, 1113.6373, 29.988591, 65.395017
4910, 1103.993, 44.991433, 73.429294
4911, 1097.8763, 14.991433, 75.130355
4912, 1089.718, 44.997158, 52.176971
4913, 1083.6013, 14.997158, 53.878032
4914, 1073.957, 30, 61.912309
4915, -151.01107, 45.49726, 126.1316
4916, -144.59211, 43.974586, 127.9828
4917, -147.94113, 50.913431, 126.62718
4918, 1119.0106, 44.991433, 69.335791
4919, 1133.9561, 29.961433, 73.32367
4920, -42.629945, 37.120912, -261.75496
4921, -30.536282, 43.525735, -260.29199
4922, -46.130852, 52.79513, -256.16564
4923, -37.044851, 35.056388, -270.29708
4924, -52.639421, 44.325782, -266.17074
4925, -40.545758, 50.730606, -264.70776
4926, -179.27398, 15.410036, -64.491086
4927, -166.53919, 17.367367, -57.168506
4928, -194.31391, 15.410036, -57.07551
4929, -181.57912, 17.367367, -49.75293
4930, -184.44345, 32.777403, -56.172466
4931, -102.99405, 22.583402, -44.219661
4932, -133.33644, 30, -46.991316
4933, -97.394025, 22.583402, -67.031594
4934, -127.73642, 30, -69.80325
4935, -103.52187, 52.583402, -64.906707
4936, 42.891271, 6.4567472, -225.99296
4937, 42.182492, 6.4567472, -237.52122
4938, 52.845312, 6.4567472, -232.49224
4939, 1071.5037, 30, 127.63029
4940, -121.3447, 60.42, 15.670192
4941, -123, 76.47, -9.184851e-15
4942, -123, 60.42, -1.8369702e-14
4943, -109.651, 79.165172, -46.542774
4944, -121.48913, 60.42, -14.978249
4945, -107.58716, 102.07422, -54.443056
4946, -119.4253, 83.329049, -22.87853
4947, -177.34018, 23.224322, -224.69713
4948, -172.66925, 8.2705299, -215.98458
4949, -167.79501, 25.897216, -218.47899
4950, -175.45257, 14.953793, -231.19477
4951, -170.57833, 32.580479, -233.68918
4952, -165.90739, 17.626687, -224.97662
4953, -189.80889, 23.290406, -214.23094
4954, -183.04704, 32.646563, -223.22298
4955, -152.58563, 47.626687, -221.03549
4956, -139.52251, 46.825049, -217.13105
4957, 15.390733, 52.508989, 188.50871
4958, 17.347669, 52.508989, 196.38718
4959, 25.283427, 52.508989, 193.72151
4960, -235.32349, 44.402929, 74.195103
4961, -245.812, 45.545737, 61.197882
4962, -248.45131, 29.948666, 74.397152
4963, -246.35422, 44.402929, 83.504182
4964, -256.84272, 45.545737, 70.506961
4965, 334.33201, 30, 137.40887
4966, 364.42043, 30, 179.53942
4967, 384.25096, 30, 132.95783
4968, 57.62192, 286.10423, -107.81014
4969, 59.458523, 259.44077, -106.99983
4970, 78.391323, 279.79838, -94.584543
4971, -169.91152, 16.134418, -1.8117083
4972, -181.64172, 16.134418, 4.0287765
4973, -181.90358, 31.3936, 8.3482194
4974, -173.37215, 15.259182, 9.3215545
4975, -185.10235, 15.259182, 15.162039
4976, -188.803, 39.199477, -5.5286417
4977, -188.26595, 31.577418, -2.54668
4978, -182.8261, 31.983812, -12.147207
4979, -193.18614, 38.914454, -14.890806
4980, -192.64909, 31.292395, -11.908844
4981, 127.51549, 30, -118.76009
4982, 160.7397, 30, -127.31438
4983, 131.23839, 30, -146.11161
4984, 180.52827, 30, -80.694371
4985, 166.68906, 30, -42.705892
4986, 199.54056, 30, -26.94441
4987, -188.55128, 23.813399, 1.7356215
4988, -191.75005, 7.6789811, 8.5494414
4989, -192.01191, 22.938164, 12.868884
4990, -165.48826, 46.722056, 215.26842
4991, -163.36676, 46.722056, 205.29218
4992, -176.61814, 46.722056, 203.927
4993, -249.55288, 44.938272, 130.30464
4994, 37.448382, 52.47, 222.95247
4995, 44.88053, 53.416099, 228.40271
4996, 45.046857, 52.364802, 215.61828
4997, 37.432148, 45.886099, 233.45024
4998, 37.598475, 44.834802, 220.66582
4999, 45.030623, 45.780902, 226.11606
5000, -129.77224, 30.804565, 183.88079
5001, -131.03911, 30.268324, 197.20959
5002, -129.77224, 23.334565, 183.88079
5003, -141.27401, 29.403758, 195.76235
5004, -141.27401, 21.933758, 195.76235
5005, -202.2571, 43.184987, 60.433344
5006, -205.74154, 43.295627, 44.142108
5007, -182.77647, 43.184987, 66.123541
5008, -193.58172, 26.480613, 58.025846
5009, -186.2609, 43.295627, 49.832305
5010, -262.07059, 29.399869, 88.702572
5011, -272.5591, 30.542677, 75.705351
5012, -270.462, 44.99694, 84.812381
5013, -226.42571, 43.927631, -64.923061
5014, -228.00533, 52.007263, -52.55715
5015, -218.47168, 52.698162, -51.594935
5016, -226.27128, 35.934895, -54.926914
5017, -216.73763, 36.625793, -53.964699
5018, -218.31725, 44.705425, -41.598788
5019, -36.049048, 22.525204, 220.93268
5020, -33.179458, 20.902645, 210.60843
5021, -32.855469, 28.03948, 214.52414
5022, -41.655721, 18.733527, 215.36234
5023, -41.331731, 25.870362, 219.27805
5024, -38.462142, 24.247803, 208.95381
5025, 114.39235, 56.82, -34.886331
5026, 114.39235, 94.62, -34.886331
5027, 100.49958, 65.155171, -68.660537
5028, -117.95935, 12.139519, 124.30228
5029, -107.61771, 17.065692, 129.51813
5030, -114.21783, 7.5651605, 131.48378
5031, -116.1656, 29.205212, 134.12555
5032, -122.76573, 19.70468, 136.0912
5033, -112.42408, 24.630853, 141.30705
5034, -197.68023, 43.388109, 152.99551
5035, -195.5029, 37.718482, 142.03531
5036, -198.65805, 36.515613, 156.30899
5037, -204.35875, 36.102322, 145.55854
5038, -196.48072, 30.845985, 145.34879
5039, -126.44721, 26.348762, 178.83382
5040, 33.712612, 53.235757, -243.02546
5041, 35.706552, 53.235757, -235.55269
5042, 34.778699, 47.897178, -240.7464
5043, -43.614575, 15.03474, 286.35757
5044, -47.735414, 30.472457, 282.30048
5045, -62.302367, 15.437717, 279.34355
5046, -46.310744, 15.437717, 272.0582
5047, -38.172539, 8.3116925, -261.5795
5048, -45.386778, 7.4495856, -250.09104
5049, -49.209839, 14.325782, -263.42079
5050, -34.278154, 15.761278, -256.58902
5051, -38.101214, 22.637475, -269.91877
5052, -45.315453, 21.775368, -258.4303
5053, -223.57152, 7.5, 37.338993
5054, -234.65508, 7.5, 35.251877
5055, -81.703888, 30, 267.23635
5056, -77.006411, 45.296268, 242.5165
5057, -91.043581, 30, 243.91817
5058, -69.475673, 15.296268, 265.96614
5059, -78.815366, 15.296268, 242.64795
5060, -180.40993, 45.259182, 38.705741
5061, -161.02527, 43.83421, 40.441743
5062, -191.21518, 28.554809, 30.608046
5063, -165.97956, 29.093393, 21.217485
5064, -171.83053, 27.129837, 32.344049
5065, 1070.5045, 45.369521, 48.046535
5066, 1064.3878, 15.369521, 49.747596
5067, 1055.9637, 30, 63.171138
5068, 1052.5111, 45.369521, 49.305365
5069, 219.17484, 30, -183.04054
5070, 276.11262, 30, -162.7136
5071, 248.84346, 30, -210.72274
5072, -208.1046, 13.295627, 43.206298
5073, -217.63408, 10.510975, 36.113853
5074, -196.86023, 13.295627, 35.960496
5075, -206.38971, 10.510975, 28.868051
5076, -206.59563, 23.806602, 34.642165
5077, -265.10015, 7.8205113, 11.674162
5078, -263.20527, 28.928038, 30.72475
5079, -255.52143, 36.303279, 26.247464
5080, -268.26057, 37.571175, 22.205995
5081, -258.62822, 25.681915, 23.804876
5082, -271.36736, 26.949811, 19.763407
5083, -263.68351, 34.325052, 15.286121
5084, -62.923538, 15.296268, 247.73779
5085, -57.60489, 30.733985, 254.6237
5086, -55.750232, 15.437717, 261.1152
5087, -121.56861, 15.834565, 193.25595
5088, -118.31636, 29.589037, 203.30772
5089, -133.07038, 14.433758, 205.13751
5090, -120.34763, 13.754471, 211.23564
5091, -129.81813, 28.188229, 215.18929
5092, 1269.7986, 14.481298, 27.785621
5093, 1273.8807, 14.481298, 12.771172
5094, 1272.7739, 29.480829, 20.750933
5095, -201.91366, 15.372087, 98.319718
5096, -189.09086, 15.372087, 101.44448
5097, -199.38293, 15.372087, 109.0975
5098, 61.700306, 44.995449, 240.34466
5099, 74.177395, 44.995449, 241.69275
5100, 64.516675, 44.995449, 226.72376
5101, -210.58794, 9.362995, 195.32483
5102, -209.76768, 9.362995, 181.98864
5103, -222.19783, 14.991435, 187.22255
5104, -214.77038, 24.35443, 190.67402
5105, -255.87675, 49.774701, 43.159069
5106, -258.42303, 49.774701, 32.809945
5107, -267.19024, 49.774701, 40.118616
5108, 12.298034, 8.8297981, 178.91353
5109, 9.1280802, 16.350192, 186.91839
5110, 9.7653321, 24.83171, 176.3843
5111, 21.033391, 7.5203935, 182.3256
5112, 21.670643, 16.001912, 171.79152
5113, 18.500689, 23.522305, 179.79638
5114, 1071.6572, 44.999534, -17.077944
5115, 1064.3499, 29.96499, -7.2143242
5116, 1068.6629, 29.998903, -24.899031
5117, 1053.8447, 44.965455, -8.329356
5118, 1058.1577, 44.999368, -26.014063
5119, 1050.8504, 29.964824, -16.150443
5120, 1071.6167, 44.999368, -31.944774
5121, 1077.2565, 29.9965, -38.983077
5122, 1041.0062, 15.369521, 34.666985
5123, 1032.5821, 30, 48.090527
5124, 31.978135, 14.587579, 248.58565
5125, 35.807215, 15.962026, 238.57513
5126, 34.005301, 21.484364, 245.70328
5127, 1063.2687, 44.965455, 0.76713207
5128, 1064.3424, 29.964994, 8.7211814
5129, -254.6107, 45.16888, -111.1857
5130, -250.1201, 30.17108, -120.916
5131, -234.4566, 45.16888, -112.6969
5132, -252.06314, 45.0022, -127.14134
5133, -85.137274, 153.20806, 87.343482
5134, -81.843298, 183.06497, 89.805472
5135, -99.138791, 155.7885, 72.803981
5136, -162.87539, 47.626687, -225.46533
5137, -139.70177, 13.83421, -1.6753914
5138, -140.00486, 13.83421, 22.512379
5139, -153.9875, 13.83421, 11.057557
5140, -97.565767, 47.065692, 129.9288
5141, -106.90047, 30.447473, 120.44474
5142, -89.823107, 31.29891, 134.10738
5143, -98.642278, 43.381781, 111.03215
5144, -81.564916, 44.233218, 124.69479
5145, -90.899618, 27.614999, 115.21073
5146, -263.64378, 36.736905, -9.3779612
5147, -264.7875, 44.099027, -6.1732113
5148, -265.14566, 36.829616, -1.7588829
5149, -178.9232, 15.849395, -26.169679
5150, -191.84288, 15.849395, -26.037841
5151, -185.75848, 15.849395, -16.291102
5152, -290.33856, 9.531447, -25.594021
5153, -291.46038, 9.531447, -9.8114801
5154, -291.14074, 24.898452, -17.242162
5155, 1071.6167, 14.999368, -31.944774
5156, -230.87294, 28.063351, -53.935493
5157, -227.96083, 28.16535, -41.408113
5158, -221.77955, 27.957262, -54.765445
5159, -223.35917, 36.036894, -42.399535
5160, -24.132907, 24.789735, 255.64899
5161, -27.547819, 17.53052, 253.39104
5162, -29.883341, 25.146382, 250.79745
5163, 1072.0307, 14.999534, -17.573764
5164, 1058.5312, 14.999368, -26.509882
5165, 1054.2182, 14.965455, -8.8251752
5166, -27.917883, 39.340113, -251.18138
5167, -22.33279, 37.275589, -259.7235
5168, -28.071185, 47.39436, -251.04588
5169, -22.486092, 45.329835, -259.58799
5170, 1317.9928, 45.821482, -26.456112
5171, 1301.8686, 45.821482, -8.8586177
5172, 1319.2504, 15.821482, -20.702975
5173, 1330.3029, 30, -14.409101
5174, -95.979613, 47.065692, 145.12204
5175, -79.978763, 44.233218, 139.88803
5176, -28.787496, 32.217267, 209.00881
5177, -29.111486, 25.080432, 205.0931
5178, 189.99592, 30, -158.10895
5179, 183.00738, 30, -194.77808
5180, 153.82845, 30, -169.8465
5181, 22.736851, 105.10683, 120.87696
5182, 40.630233, 110.99604, 115.23316
5183, 21.102777, 131.64436, 121.15591
5184, 1080.1487, 30.366679, 40.012258
5185, 1074.4555, 45.369521, 32.886464
5186, 1071.5413, 30.36906, 25.894961
5187, -168.19751, 30.272471, -207.03721
5188, -164.65545, 18.805734, -207.78843
5189, -161.43566, 39.628627, -216.02925
5190, -158.2961, 32.537145, -205.33869
5191, -157.8936, 28.16189, -216.78047
5192, -33.744318, 281.39805, 118.08894
5193, -37.546257, 307.4008, 116.70496
5194, -179.52509, 22.312702, -127.17452
5195, -179.93912, 30.036605, -127.34593
5196, -184.60185, 26.774628, -130.51141
5197, -206.64627, 27.842369, 62.699322
5198, -214.03004, 27.587916, 80.855728
5199, -205.90707, 13.184987, 73.288629
5200, -230.57903, 29.060311, 69.237968
5201, -222.45605, 14.657382, 61.670869
5202, -229.83983, 14.402929, 79.827274
5203, -187.7598, 45.372087, 98.331125
5204, -184.35239, 43.184987, 84.951489
5205, -205.41774, 45.372087, 90.961032
5206, -202.01033, 43.184987, 77.581396
5207, -193.50469, 28.557074, 87.696719
5208, 62.862485, 16.460944, 259.02672
5209, 68.94034, 16.460944, 276.85728
5210, 79.370621, 16.460944, 253.62207
5211, -274.12277, 29.626299, -59.196833
5212, -262.73843, 23.838392, -52.15693
5213, -262.28608, 14.259227, -60.997959
5214, -283.42264, 24.946238, -48.537522
5215, -282.97029, 15.367073, -57.378551
5216, -271.58595, 9.5791652, -50.338648
5217, -199.66052, 45.372087, 106.5429
5218, -179.82797, 31.405453, -119.88681
5219, -172.99693, 37.832801, -126.21705
5220, -172.5829, 30.108899, -126.04565
5221, -36.239467, 14.955299, 105.86962
5222, -29.685582, 45.39062, 109.02581
5223, -49.107078, 29.188516, 128.76224
5224, -60.954646, 14.233218, 105.98075
5225, -54.400761, 44.668539, 109.13694
5226, 81.419599, 30.865008, 273.72528
5227, 96.755693, 14.404063, 264.40201
5228, -125.4053, 30.682033, 174.16475
5229, -116.59923, 37.273609, 175.47503
5230, -126.61112, 34.070627, 179.22816
5231, -122.46719, 36.286511, 164.31176
5232, -123.67301, 39.675105, 169.37517
5233, -20.719734, 82.014828, 119.63067
5234, -21.601932, 121.56089, 119.27538
5235, -38.225395, 80.029657, 116.7768
5236, -39.107593, 119.57572, 116.42151
5237, -58.738946, 298.30575, 103.9513
5238, -121.32163, 43.754471, 246.87671
5239, -134.36501, 28.661824, 240.0722
5240, -123.67961, 43.754471, 227.65336
5241, -140.94925, 44.907353, 246.43814
5242, -112.97748, 15.834565, 187.21009
5243, -111.7565, 13.754471, 205.18978
5244, -122.67249, 15.834565, 184.3088
5245, 13.319715, 45.179809, 194.78031
5246, 20.197972, 44.899699, 198.52583
5247, -107.45558, 30, 59.837758
5248, -98.033264, 30, 73.33429
5249, -105.16504, 76.640108, 63.442891
5250, -95.742723, 76.640108, 76.939423
5251, -127.68196, 13.754471, 218.49121
5252, -140.40471, 14.433758, 212.39308
5253, -97.367059, 11.872371, -104.44299
5254, -109.97505, 14.06307, -91.22353
5255, -119.97858, 25.935441, -107.44171
5256, -111.05904, 11.872371, -116.13086
5257, -123.66703, 14.06307, -102.9114
5258, 93.570771, 30, -109.17372
5259, 97.293667, 30, -136.52524
5260, -216.55731, 33.028982, -188.65789
5261, -211.13218, 48.047248, -194.63182
5262, -205.37145, 33.067124, -200.32613
5263, -157.70932, 44.908047, 65.06487
5264, -144.1324, 44.908047, 81.57935
5265, -135.81768, 44.908047, 72.024743
5266, -117.15556, 7.5651605, 153.51023
5267, -115.23986, 11.971833, 161.56854
5268, -107.73897, 7.5651605, 143.95918
5269, -117.10851, 19.536993, 151.33101
5270, -105.82327, 11.971833, 152.0175
5271, -123.29702, 7.894222, 161.34397
5272, -125.16567, 15.459383, 151.10645
5273, -123.24996, 19.866055, 159.16476
5274, -132.90739, 7.5, 182.86156
5275, -131.80351, 7.5, 191.80871
5276, 718.06864, 30, 141.19775
5277, -101.13884, 17.065692, 141.99353
5278, -110.50838, 29.037525, 149.36536
5279, -96.7519, 31.239153, 152.94476
5280, -92.066784, 14.17346, 155.59689
5281, -101.43632, 26.145293, 162.96873
5282, -101.48338, 14.17346, 165.14794
5283, -114.18328, 13.754471, 218.71577
5284, -235.90354, 14.993167, 164.1092
5285, -227.32001, 24.754976, 165.86478
5286, -238.14902, 30.23615, 157.75605
5287, -217.45292, 9.7618092, 157.93678
5288, -228.28193, 15.242982, 149.82805
5289, -219.6984, 25.004792, 151.58363
5290, 20.161206, 14.530426, 143.80067
5291, 32.692003, 14.530426, 130.20551
5292, 34.049202, 14.530426, 146.94853
5293, -222.43635, 14.981735, -186.6615
5294, -232.32848, 15.057977, -173.81845
5295, 1218.2111, 44.97, -75.688404
5296, 1232.3979, 30, -91.225858
5297, 1212.1496, 44.938971, -90.689791
5298, 1214.1868, 14.97, -75.537455
5299, 1193.9385, 29.908971, -75.001387
5300, 1208.1253, 14.938971, -90.538842
5301, 45.159137, 48.856823, -156.68709
5302, 25.322579, 33.80785, -165.70026
5303, 33.855983, 48.856823, -171.35551
5304, 30.530501, 44.951027, -150.30421
5305, 19.227348, 44.951027, -164.97263
5306, 39.441395, 11.970914, -194.71049
5307, 42.124383, 20.410253, -199.78024
5308, 35.022006, 20.440269, -189.32469
5309, 34.883235, 8.4393393, -202.78235
5310, 27.780857, 8.4693554, -192.3268
5311, 30.463845, 16.908695, -197.39656
5312, -194.43574, 17.127862, 181.38252
5313, -191.63876, 24.853151, 184.63556
5314, -195.97149, 24.75857, 178.18921
5315, 1265.3489, 30, -101.42078
5316, 1245.9069, 30, -113.49947
5317, 1251.8399, 30, -79.147165
5318, -187.61861, 34.264975, -123.96389
5319, -180.78757, 40.692323, -130.29413
5320, -185.45031, 37.430347, -133.45962
5321, -202.36441, 15.216347, 137.26128
5322, -195.82338, 9.3812757, 145.03242
5323, -205.70839, 9.7618092, 149.80829
5324, -195.64039, 24.597623, 142.36949
5325, -205.5254, 24.978156, 147.14535
5326, -198.98438, 19.143085, 154.9165
5327, 162.86175, 30, 136.85647
5328, 205.65738, 30, 139.90589
5329, 196.42751, 30, 87.087808
5330, 1327.4272, 30, 11.246056
5331, 1317.8042, 44.481298, 25.339433
5332, 1309.9644, 30, -2.6988241
5333, 1297.3847, 14.481298, 11.260473
5334, 1300.3414, 44.481298, 11.394553
5335, -177.07355, 53.827965, 127.50597
5336, -178.66509, 43.620198, 129.10005
5337, -182.54485, 52.47, 130.99294
5338, -184.24769, 49.792233, 123.57281
5339, -184.13639, 42.262233, 132.58701
5340, 309.04754, 30, -195.08781
5341, 366.61372, 30, -184.14198
5342, -183.66566, 31.678008, -78.022958
5343, -170.93087, 33.63534, -70.700377
5344, -165.76141, 16.267973, -79.018998
5345, 41.824058, 11.970914, -183.19172
5346, 30.16352, 8.4693554, -180.80803
5347, -209.32541, 30.717773, 106.89199
5348, -199.54676, 30.588435, 117.83735
5349, -211.96007, 30.562033, 123.65298
5350, -211.79624, 15.345686, 114.91314
5351, -202.01759, 15.216347, 125.8585
5352, -186.4226, 46.267973, -89.117219
5353, -201.29833, 48.471143, -97.878238
5354, -202.35511, 40.418945, -88.178562
5355, -185.02881, 34.739116, -101.31189
5356, -186.08559, 26.686918, -91.612213
5357, -200.96131, 28.890088, -100.37323
5358, -180.67642, 42.061171, -122.83501
5359, -190.51294, 25.934974, 110.77143
5360, -192.98378, 10.562886, 118.79258
5361, -193.1476, 25.779234, 127.53243
5362, 1068.7179, 44.999539, 17.713123
5363, 1058.1118, 45.369521, 27.699985
5364, 1050.9129, 44.965455, 10.526206
5365, 1053.7363, 30.334977, 18.708043
5366, 123, 94.62, -1.2858791e-15
5367, 123, 56.82, -1.2858791e-15
5368, 1119.0106, 14.991433, 69.335791
5369, 39.353379, 338.66557, -115.96402
5370, -36.097254, 53.827651, 215.57465
5371, 36.544292, 40.600892, 215.14185
5372, 36.669247, 47.025195, 215.46837
5373, 596.19048, 30, 153.30514
5374, 40.58638, 304.70389, 115.42651
5375, 40.58638, 334.70389, 115.42651
5376, -36.059342, 28.852501, 236.04352
5377, -35.927193, 32.858599, 228.42589
5378, -41.986536, 31.7711, 236.4694
5379, -34.967834, 36.364247, 241.6608
5380, -34.835685, 40.370344, 234.04317
5381, -44.109102, 54.47581, 234.71979
5382, -36.983217, 46.957555, 234.63559
5383, -45.684767, 47.435983, 238.23589
5384, -34.942869, 52.481745, 239.31877
5385, -43.644419, 52.960173, 242.91907
5386, -36.518533, 45.441919, 242.83486
5387, -193.92572, 31.205389, -128.65806
5388, -193.33735, 30.275772, -115.5443
5389, -194.77417, 41.861107, -131.60626
5390, -200.49291, 37.871904, -123.18667
5391, -194.1858, 40.93149, -118.4925
5392, 1074.4555, 15.369521, 32.886464
5393, -31.146372, 45.15528, 275.10961
5394, -42.310892, 45.03474, 286.50016
5395, -26.424919, 45.15528, 286.15045
5396, -33.874725, 30.19002, 285.20929
5397, 21.569148, 32.555381, 259.86989
5398, 27.657854, 37.244379, 252.61367
5399, 22.6825, 39.103505, 258.95732
5400, 31.344494, 33.98329, 260.39589
5401, 28.771206, 43.792503, 251.70109
5402, -175.3554, 46.134418, -11.469595
5403, -183.71307, 46.134418, -7.6618141
5404, -179.73855, 45.849395, -20.831759
5405, -188.09621, 45.849395, -17.023978
5406, 1069.0789, 14.999539, 15.829744
5407, 1051.274, 14.965455, 8.6428272
5408, 1058.4729, 15.369521, 25.816606
5409, 703.25733, 30, -45.015936
5410, 1063.2687, 14.965455, 0.76713207
5411, -21.129931, 25.746216, 197.73955
5412, -12.54904, 24.662725, 194.20869
5413, -16.090745, 17.016578, 194.91402
5414, -198.85449, 43.616387, 159.71295
5415, -198.06942, 36.28155, 163.72853
5416, -205.57678, 41.303193, 168.96317
5417, -197.89518, 43.147632, 172.15737
5418, -197.11011, 35.812794, 176.17295
5419, -30.996907, 14.955299, 125.26529
5420, -13.566075, 14.955299, 129.00397
5421, -24.879669, 14.955299, 141.34702
5422, 16.264573, 16.001912, 160.3003
5423, 8.570789, 30.165356, 162.52866
5424, 8.9430929, 16.001912, 170.23007
5425, 5.6974206, 14.163444, 153.56667
5426, -1.6240591, 14.163444, 163.49644
5427, -100.34491, 15.921808, 206.34071
5428, -103.25701, 29.676279, 208.91235
5429, -86.554464, 31.187496, 209.12171
5430, -97.480734, 15.265688, 218.92513
5431, -100.39283, 29.020159, 221.49677
5432, -31.955493, 49.427018, 183.11181
5433, -27.12907, 34.593878, 181.27623
5434, -26.717221, 41.603592, 190.01106
5435, -23.914882, 45.166859, 172.79483
5436, -23.503032, 52.176574, 181.52965
5437, -18.676609, 37.343433, 179.69407
5438, -125.62933, 7.5651605, 148.37941
5439, -127.52061, 15.243149, 144.11031
5440, 1100.3367, 14.997132, -69.113969
5441, 1115.0029, 30.018034, -64.437697
5442, 1100.2969, 44.997132, -68.876355
5443, 1115.99, 15.020902, -89.420663
5444, 1101.284, 30, -93.859321
5445, 1115.9502, 45.020902, -89.183049
5446, -55.712086, 14.233218, 125.37642
5447, 23.056481, 15.479188, -197.69337
5448, 30.158858, 15.449172, -208.14892
5449, 27.475871, 7.0098323, -203.07916
5450, 1084.4786, 30, -73.823818
5451, 1083.4915, 44.997132, -48.840853
5452, -46.041619, 50.319616, 257.42647
5453, -33.183929, 50.319616, 257.90854
5454, -36.927917, 50.319616, 267.05464
5455, -14.798155, 52.176574, 187.71703
5456, -4.9970943, 51.063427, 185.67511
5457, -8.4636986, 43.240001, 186.38697
5458, -10.559635, 52.176574, 178.65245
5459, -0.75857419, 51.063427, 176.61053
5460, 1135.3281, 15.020902, -72.372195
5461, 1135.3281, 29.990902, -72.372195
5462, 1150.0881, 15.020902, -72.372195
5463, 1264.1426, 29.478415, 34.800679
5464, 1269.7986, 44.481298, 27.785621
5465, 1195.0162, 44.97, 75.368173
5466, 1182.363, 45.007877, 88.019419
5467, 1206.2586, 44.951341, 90.348972
5468, 1187.3468, 29.977877, 72.651246
5469, 1211.2424, 29.921341, 74.980799
5470, 1198.5891, 29.959218, 87.632044
5471, -265.18457, 14.610587, 5.3115018
5472, -265.915, 6.7900757, 0.64035469
5473, -273.74573, 6.7900757, 7.7376169
5474, -61.52225, 28.847199, 150.69836
5475, -68.451042, 28.787442, 169.53573
5476, -57.461456, 14.613981, 165.22444
5477, -80.751049, 28.406678, 147.71075
5478, -69.761462, 14.233218, 143.39946
5479, -76.690254, 14.17346, 162.23683
5480, 15.813056, 31.176164, 184.99255
5481, 6.4404474, 24.00405, 192.11456
5482, 15.175804, 22.694646, 195.52663
5483, -225.59762, 22.157382, 40.540781
5484, -233.71318, 23.723228, 46.937568
5485, -221.16914, 14.657382, 47.879774
5486, -236.11556, 16.565846, 36.396787
5487, -231.68708, 9.0658456, 43.73578
5488, -3.4347139, 167.88115, 120.82053
5489, 21.580349, 167.5527, 121.05906
5490, 3.7597941, 197.5183, 121.75169
5491, -119.4253, 116.62905, -22.87853
5492, 518.95865, 30, 151.85784
5493, 19.356879, 8.4693554, -194.58342
5494, 16.374287, 16.27872, -193.22373
5495, 34.960435, 40.669439, -220.83239
5496, 34.864738, 41.144771, -228.27994
5497, 34.960435, 33.169439, -220.83239
5498, 34.864738, 33.644771, -228.27994
5499, 39.825174, 36.874209, -221.11233
5500, 834.82235, 30, 122.07324
5501, 853.8867, 30, 99.221516
5502, 851.3702, 30, 141.98217
5503, -69.320444, 30.535789, 184.53031
5504, -53.109013, 32.765084, 191.2312
5505, -65.344529, 14.613981, 184.43937
5506, -73.207213, 34.072911, 203.23817
5507, -85.44273, 15.921808, 196.44634
5508, -69.231299, 18.151103, 203.14722
5509, 42.92962, 6.4533455, 224.79746
5510, 41.841815, 6.4533455, 212.87183
5511, 53.794973, 6.4533455, 216.79184
5512, -0.42951601, 8.8297981, 177.35208
5513, -169.2561, 27.944967, -14.434126
5514, -173.63924, 27.659944, -23.79629
5515, -166.16854, 41.810549, -23.118677
5516, -88.27141, 15.265688, 232.87787
5517, -82.578549, 15.265688, 209.03076
5518, -73.275816, 15.265688, 221.5553
5519, -123, 301.32, -9.184851e-15
5520, -123, 262.62, -9.184851e-15
5521, -114.72566, 275.59382, 34.244503
5522, -114.72566, 236.89382, 34.244503
5523, 476.96427, 30, 117.77105
5524, -91.616856, 14.233218, 124.28411
5525, -85.137992, 14.233218, 136.75952
5526, -78.335863, 328.30575, 94.793703
5527, -57.143175, 337.4008, 107.54736
5528, -211.13218, 18.047248, -194.63182
5529, -11.292124, 8.8297981, 180.66881
5530, -22.899997, 9.2212673, 184.08116
5531, -21.032715, 15.166859, 174.39528
5532, -11.215149, 18.051065, 186.91866
5533, -9.3478676, 23.996658, 177.23278
5534, -20.95574, 24.388127, 180.64512
5535, -136.04129, 14.06307, -108.12741
5536, -144.56622, 9.4782499, -119.62316
5537, -134.95187, 16.211283, -123.62229
5538, -141.11152, 23.54132, -105.718
5539, -131.49716, 30.274353, -109.71713
5540, -140.0221, 25.689533, -121.21288
5541, -164.20764, 17.626687, -238.21767
5542, -10.778108, 280.63092, 121.94274
5543, -8.3882101, 249.45215, 122.38886
5544, -31.35442, 250.21928, 118.53506
5545, 415.57768, 30, -1.2224109
5546, 385.44757, 30, -21.549595
5547, 426.04692, 30, -33.053816
5548, 395.9168, 30, -53.381001
5549, -161.77103, 54.582936, 197.79195
5550, -155.79623, 53.822068, 196.91051
5551, -145.56248, 32.513107, 198.7602
5552, -146.32306, 26.772988, 199.08822
5553, -21.306992, 227.97105, -119.19489
5554, -21.109362, 254.93768, -119.18568
5555, -43.337216, 251.6782, -114.92506
5556, -24.49435, 50.319616, 265.85366
5557, -28.49175, 35.474896, 265.76377
5558, -18.712804, 45.15528, 273.90863
5559, 66.222667, 30, -127.54966
5560, 31.689358, 24.601548, -114.41119
5561, 46.374679, 30, -138.21883
5562, 55.529725, 54.601548, -106.81424
5563, 35.681737, 54.601548, -117.48341
5564, 123, 249.24, -1.2858791e-15
5565, 123, 198.24, -1.2858791e-15
5566, 110.20093, 234.76761, -41.905176
5567, -169.9171, 47.367367, -53.997516
5568, -183.58959, 47.367367, -50.641602
5569, -182.65189, 45.410036, -61.320097
5570, -196.32438, 45.410036, -57.964182
5571, 32.001861, 44.647146, 272.85549
5572, 19.365732, 44.647146, 271.18338
5573, 28.055863, 44.647146, 263.61242
5574, 1195.0012, 14.97, 75.644178
5575, 1182.3479, 15.007877, 88.295424
5576, 1174.0268, 15.007877, 72.651246
5577, -186.39516, 38.071968, -114.41542
5578, 18.480075, 8.4693554, -186.34802
5579, 11.492894, 7.809365, -192.63075
5580, 103.00766, 30, -162.5203
5581, 125.59772, 30, -186.25519
5582, -137.1051, 25.377079, -193.28788
5583, -132.16692, 29.678628, -190.00675
5584, -132.16692, 22.208628, -190.00675
5585, 16.715938, 37.906773, 262.25824
5586, 4.5558634, 38.251967, 266.15681
5587, 14.141078, 29.640749, 262.74954
5588, 13.095713, 29.639486, 271.55068
5589, 1.9810037, 29.985943, 266.6481
5590, 22.177803, 29.210875, 283.52175
5591, 20.047983, 14.647146, 271.0039
5592, 10.017729, 29.556069, 287.42031
5593, 7.887909, 14.99234, 274.90247
5594, 16.969999, 14.563729, 286.87353
5595, -129.2649, 46.825049, -212.29749
5596, 735.37058, 30, 105.88539
5597, 719.0027, 30, 78.291128
5598, 701.84663, 30, 109.9277
5599, -123.81572, 46.099324, 169.69487
5600, -126.75383, 40.494846, 179.54786
5601, 16.852195, 21.214174, 262.21895
5602, 4.6921203, 21.559368, 266.11751
5603, 82.646482, 35.155171, -82.97158
5604, 114.9316, 30, -84.083705
5605, 108.01174, 30, -58.799216
5606, 110.20093, 277.06761, -41.905176
5607, 98.550933, 280.4104, -73.252864
5608, 114.12279, 334.44, -35.394587
5609, 102.47279, 337.78279, -66.742275
5610, 0.656389, 44.99234, 287.72451
5611, -6.8898826, 44.99234, 274.72389
5612, 7.2056579, 44.99234, 275.08195
5613, -117.36507, 27.806398, 172.35868
5614, -103.60859, 30.008026, 175.93807
5615, -114.42696, 33.410876, 162.50569
5616, -100.67048, 35.612504, 166.08508
5617, 114.22424, 334.44, 35.204395
5618, 123, 334.44, -1.2858791e-15
5619, -206.83317, 9.7618092, 161.35579
5620, -199.52559, 9.7618092, 156.54373
5621, 51.391231, 46.460944, 270.5021
5622, 57.200636, 46.460944, 262.23999
5623, 68.94034, 46.460944, 276.85728
5624, 427.35782, 30, 172.59711
5625, 438.72567, 30, 129.93715
5626, -234.84612, 20.78054, -42.741982
5627, -225.75273, 20.674451, -43.571935
5628, -230.31901, 14.14482, -37.452902
5629, -232.52711, 21.63572, -35.28908
5630, -223.43372, 21.529631, -36.119033
5631, 52.824479, 24.92297, 256.0478
5632, 33.435109, 23.109172, 258.40119
5633, 39.523815, 27.79817, 251.14496
5634, 44.645157, 31.10809, 265.29873
5635, 50.733864, 35.797088, 258.0425
5636, 1234.6294, 14.997159, -67.494259
5637, 1238.6537, 44.997159, -67.645208
5638, -152.01241, 28.677714, -197.41384
5639, -155.55448, 40.144451, -196.66261
5640, -157.13314, 25.391464, -198.6308
5641, -160.67521, 36.858201, -197.87957
5642, -137.95084, 50.913431, 115.57692
5643, -133.45668, 52.327707, 105.67919
5644, -127.25404, 50.913431, 124.43652
5645, -137.99301, 43.241138, 111.09774
5646, -122.75989, 52.327707, 114.53879
5647, 1193.9385, 44.938971, -75.001387
5648, 1178.6985, 44.938971, -75.001387
5649, 1190.1042, 44.938971, -91.666509
5650, -191.29969, 22.723588, -202.68453
5651, -176.04767, 15.974242, -197.94053
5652, -188.42381, 30.210984, -204.13645
5653, -173.17178, 23.461638, -199.39245
5654, -146.4855, 10.535204, -202.9792
5655, -136.56195, 16.825049, -209.76532
5656, -150.64642, 10.535204, -215.51571
5657, -144.83048, 27.360253, -212.87603
5658, -140.72287, 16.825049, -222.30183
5659, -124.72243, 42.637907, -151.21663
5660, -124.74654, 34.580259, -150.8631
5661, -115.02849, 39.972412, -154.10117
5662, -121.57393, 46.502854, -162.41709
5663, -121.59804, 38.445207, -162.06356
5664, 1175.7086, 30, -124.87701
5665, 1169.6472, 44.938971, -94.878399
5666, 1193.9385, 44.938971, -120.00139
5667, 1193.9385, 14.938971, -120.00139
5668, 31.812584, 8.4393393, -210.49417
5669, 33.783111, 15.939339, -217.92605
5670, -37.33036, 13.358952, -173.68246
5671, -37.148349, 30.686888, -173.7233
5672, -36.87197, 22.577163, -183.60978
5673, -22.378244, 17.327936, -167.00702
5674, -22.101866, 9.2182109, -176.89351
5675, -21.919854, 26.546147, -176.93435
5676, -127.21481, 16.825049, -218.99735
5677, -41.064712, 12.719601, -161.48028
5678, -55.834816, 26.078552, -168.19655
5679, -52.502073, 13.358952, -173.3654
5680, -56.236424, 12.719601, -161.16322
5681, -122.44464, 43.830253, 163.07857
5682, -222.27108, 44.981735, -186.65326
5683, -211.39576, 48.047248, -179.67271
5684, -232.16321, 45.057977, -173.81022
5685, -226.44945, 33.105225, -175.81484
5686, -122.31147, 13.754471, 246.41624
5687, -125.48186, 13.754471, 229.54985
5688, -142.75149, 14.907353, 248.33463
5689, -61.230368, 262.61483, 101.12209
5690, -86.224996, 279.52253, 86.984446
5691, -68.936379, 43.358952, -173.19386
5692, -72.365496, 28.19509, -179.59685
5693, -72.67073, 42.719601, -160.99168
5694, -89.20141, 44.836138, -172.39198
5695, -76.099848, 27.555739, -167.39468
5696, 681.06264, 30, 86.371974
5697, 659.18696, 30, 108.24766
5698, -88.549242, 30.095268, 181.5427
5699, -84.573328, 14.17346, 181.45176
5700, 1289.2889, 30.30278, 5.100679
5701, 1274.3011, 30.821014, 0.49776274
5702, 1286.1086, 45.821482, 1.2849336
5703, 1284.5814, 44.481298, 21.538104
5704, 1269.5936, 44.999531, 16.935188
5705, -110.40389, 45.834565, 195.29976
5706, -104.47799, 31.756373, 190.93265
5707, -109.18291, 43.754471, 213.27946
5708, -95.344546, 45.921808, 200.90439
5709, 81.212164, 44.875405, -141.8129
5710, 86.926153, 44.875405, -167.80796
5711, 88.442797, 14.875405, -158.38545
5712, -121.66585, 43.754471, 214.17786
5713, -134.38861, 44.433758, 208.07974
5714, -136.40237, 44.433758, 221.55523
5715, -183.76404, 15.003536, -34.307448
5716, -171.17291, 17.367367, -39.839936
5717, -184.29979, 32.370903, -43.317398
5718, -192.05008, 30.852931, -29.647141
5719, -179.45895, 33.216761, -35.179629
5720, -118.25478, 51.439043, 175.08176
5721, -128.40938, 54.660281, 179.15458
5722, -121.19289, 45.834565, 184.93475
5723, 1274.3632, 30.821019, -15.424688
5724, 1275.4079, 15.821482, -7.481998
5725, -44.004187, 23.169465, 188.78072
5726, -30.804576, 17.776751, 197.68455
5727, -36.977907, 27.982502, 198.31566
5728, -36.022633, 23.835249, 181.42717
5729, -42.195963, 34.041, 182.05828
5730, -28.996352, 28.648286, 190.96211
5731, -169.7807, 44.440167, 126.5432
5732, -176.95484, 40.404435, 122.61004
5733, -175.3633, 50.612202, 121.01597
5734, 682.99801, 30, 146.27165
5735, -147.08776, 29.341112, 233.97407
5736, 831.17688, 30, -122.22085
5737, -121.06856, 17.298668, -160.80663
5738, -122.62219, 18.074651, -152.99095
5739, -121.07689, 26.801938, -158.52083
5740, -225.59762, 29.627382, 40.540781
5741, -219.66018, 25.168358, 39.315641
5742, -269.95972, 14.350119, -9.0237059
5743, -266.96488, 20.289044, -12.615676
5744, -261.68117, 15.326127, -12.993253
5745, -270.83531, 19.519077, -2.2170134
5746, -265.55161, 14.55616, -2.5945899
5747, -262.55677, 20.495085, -6.1865603
5748, -258.80328, 16.081527, -28.598996
5749, -266.68847, 25.774108, -22.834318
5750, -269.06379, 17.139208, -30.459994
5751, -259.40247, 26.735549, -32.010945
5752, -261.77779, 18.100649, -39.63662
5753, -269.66298, 27.79323, -33.871943
5754, -97.918136, 15.921808, 192.81472
5755, -77.327283, 94.323148, 92.179594
5756, -83.982641, 76.640108, 87.776123
5757, -91.022989, 94.229473, 81.856921
5758, -89.653739, 237.51213, -81.720085
5759, -108.74132, 216.21573, -57.302805
5760, -80.778468, 196.91822, -92.717818
5761, -99.866052, 175.62182, -68.300538
5762, 13.314808, 14.530426, 116.13127
5763, 27.637271, 42.102134, 113.99178
5764, 33.398066, 27.571708, 107.93426
5765, -129.89099, 52.67289, 144.18935
5766, -135.94138, 52.67289, 136.37596
5767, -139.34967, 50.913431, 124.12497
5768, -97.048735, 14.17346, 177.82014
5769, 76.612846, 44.740082, -241.54619
5770, 91.874783, 44.740082, -265.29361
5771, 68.132029, 44.740082, -271.18855
5772, -80.723003, 225.64664, 91.262599
5773, -104.21171, 254.8906, 64.224429
5774, -42.628447, 46.961818, 224.52731
5775, -40.480915, 40.374607, 223.93489
5776, -48.051613, 40.637111, 214.47853
5777, -44.001919, 42.364408, 229.44419
5778, -51.572616, 42.626912, 219.98783
5779, -49.425084, 36.039701, 219.39541
5780, 49.349046, 52.364802, 204.32223
5781, 38.047832, 52.364802, 205.01762
5782, -117.41213, 15.834565, 174.53789
5783, 1067.5213, 30, -53.993219
5784, 1083.3794, 14.997132, -49.28337
5785, -2.830055, 22.465687, 266.3576
5786, 4.122215, 7.473347, 265.81082
5787, 11.64439, 6.5670283, 265.57073
5788, 1061.3984, 44.999368, -43.692926
5789, 1061.2863, 14.999368, -44.135443
5790, -10.625794, 7.473347, 265.76371
5791, -6.8600995, 14.99234, 274.85536
5792, 34.050371, 36.27494, -215.68713
5793, 33.749322, 30.537363, -214.92759
5794, 29.636604, 34.720511, -209.37064
5795, -176.85445, 47.626687, -228.70949
5796, -164.20764, 47.626687, -238.21767
5797, -141.27017, 14.433758, 202.87168
5798, 20.265641, 45.878462, -197.03676
5799, 25.044333, 51.304277, -190.88461
5800, 17.809384, 51.304277, -195.24876
5801, 24.799903, 54.574185, -199.50616
5802, 7.4307771, 52.693044, -263.05724
5803, 0.99959971, 43.434667, -263.79184
5804, 10.377178, 44.036031, -264.65781
5805, 1.399282, 50.741623, -269.68466
5806, 10.776861, 51.342987, -270.55062
5807, 4.3456832, 42.08461, -271.28522
5808, 34.456893, 6.4567472, -238.45283
5809, 33.031389, 7.6703851, -247.163
5810, 35.238231, 16.969394, -236.88832
5811, 41.47616, 14.127132, -242.67028
5812, 33.812727, 18.183032, -245.59849
5813, 30.456114, 38.959211, -202.78473
5814, 30.79055, 47.012324, -203.07563
5815, 34.381845, 46.254554, -207.92285
5816, -254.3989, 15.16888, -111.68879
5817, -235.89259, 15.16888, -114.0229
5818, -253.49913, 15.0022, -128.46733
5819, 31.03498, 43.742416, -194.45409
5820, 30.230643, 40.161101, -180.24918
5821, 40.755552, 41.294962, -186.28805
5822, 35.569242, 52.438139, -196.92348
5823, 34.764905, 48.856823, -182.71857
5824, 35.543765, 53.816415, -219.17871
5825, 33.562335, 42.015853, -214.50876
5826, 41.902301, 48.199439, -218.33473
5827, 42.72181, 52.438139, -211.74882
5828, 40.74038, 40.637578, -207.07887
5829, -129.58236, 10.514197, 177.81459
5830, 86.472782, 310.14251, -87.139324
5831, 90.469475, 250.06627, -80.698083
5832, 33.01744, 28.491986, -198.39244
5833, 43.301707, 30.170352, -202.68658
5834, 44.121217, 34.409053, -196.10067
5835, 8.3162649, 7.6781927, 192.96972
