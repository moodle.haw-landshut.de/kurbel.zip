*Heading
Kurbel, parabolische Tetraeder, feines Netz
*Node
1, 73.846154, 0, -290.76923
2, 73.846154, 0, 290.76923
3, 1200, 0, 150
4, 1200, 0, -150
5, 96, 0, -2.094146e-14
6, -96, 0, 1.4328368e-14
7, 690, 0, -1.4695762e-14
8, 450, 0, 2.9391523e-14
9, 990, 0, -1.1021821e-14
10, 810, 0, 2.2043642e-14
11, 30, 0, -228
12, -30, 0, -228
13, -140.00714, 0, -182.43355
14, -182.43355, 0, -140.00714
15, -228, 0, -30
16, -228, 0, 30
17, -182.43355, 0, 140.00714
18, -140.00714, 0, 182.43355
19, -30, 0, 228
20, 30, 0, 228
21, 1200, 0, -60
22, 1140, 0, -60
23, 1200, 0, 60
24, 1140, 0, 60
25, 73.846154, 60, 290.76923
26, 73.846154, 60, -290.76923
27, 1200, 60, -150
28, 1200, 60, 150
29, 150, 60, 1.8369702e-14
30, -150, 60, -3.6739404e-14
31, 690, 60, -1.4695762e-14
32, 450, 60, 2.9391523e-14
33, 990, 60, -1.1021821e-14
34, 810, 60, 2.2043642e-14
35, 30, 60, -228
36, -30, 60, -228
37, -140.00714, 60, -182.43355
38, -182.43355, 60, -140.00714
39, -228, 60, -30
40, -228, 60, 30
41, -182.43355, 60, 140.00714
42, -140.00714, 60, 182.43355
43, -30, 60, 228
44, 30, 60, 228
45, 1200, 60, -60
46, 1140, 60, -60
47, 1140, 60, 60
48, 1200, 60, 60
49, 20, 300, -148.66069
50, 20, 360, -148.66069
51, 150, 360, 1.8369702e-14
52, -150, 360, -1.8369702e-14
53, -20, 360, -148.66069
54, -20, 300, -148.66069
55, 20, 300, -93.893557
56, -20, 300, -93.893557
57, -20, 300, 148.66069
58, 20, 300, 148.66069
59, -20, 300, 93.893557
60, 20, 300, 93.893557
61, 20, 360, 148.66069
62, 20, 360, 93.893557
63, 20, 360, -93.893557
64, -20, 360, -93.893557
65, -96, 360, 0
66, -20, 360, 93.893557
67, -20, 360, 148.66069
68, 96, 360, -2.094146e-14
69, 37.397526, 0, -297.65992
70, 4.7437565, 0, -299.96249
71, -23.615886, 0, -299.06904
72, -52.839264, 0, -295.31003
73, -95.114318, 0, -284.52288
74, -136.35099, 0, -267.22352
75, -167.38212, 0, -248.96431
76, -193.51124, 0, -229.24528
77, -216.58237, 0, -207.58631
78, -237.91031, 0, -182.75307
79, -256.4056, 0, -155.74391
80, -276.28424, 0, -116.90601
81, -290.59251, 0, -74.538522
82, -297.70669, 0, -37.0233
83, -299.95034, 0, -5.4582178
84, -298.85658, 0, 26.167595
85, -292.87746, 0, 64.983022
86, -278.36551, 0, 111.85993
87, -255.26531, 0, 157.6059
88, -236.57394, 0, 184.47973
89, -218.83565, 0, 205.20955
90, -195.17455, 0, 227.83085
91, -167.38212, 0, 248.96431
92, -127.52757, 0, 271.54506
93, -74.17315, 0, 290.68599
94, -31.225612, 0, 298.37051
95, 0.37713894, 0, 299.99976
96, 31.975694, 0, 298.29106
97, 121.33166, 0, 278.97935
98, 183.35739, 0, 264.38762
99, 275.64755, 0, 244.353
100, 394.07953, 0, 221.54386
101, 499.5753, 0, 203.93483
102, 590.79043, 0, 190.74276
103, 677.73089, 0, 179.90814
104, 773.92526, 0, 169.88361
105, 849.8854, 0, 163.41642
106, 919.12823, 0, 158.62988
107, 995.25573, 0, 154.58374
108, 1072.5775, 0, 151.77482
109, 1134.0071, 0, 150.47599
110, 1265.9909, 0, 134.70414
111, 1321.6289, 0, 87.786113
112, 1346.9783, 0, 29.956497
113, 1347.6847, 0, -26.253459
114, 1323.7966, 0, -84.701843
115, 1265.1432, 0, -135.11611
116, 1129.4562, 0, -150.5439
117, 1064.6158, 0, -152.00359
118, 989.57235, 0, -154.84188
119, 919.12823, 0, -158.62988
120, 858.96218, 0, -162.72883
121, 786.38877, 0, -168.735
122, 686.77519, 0, -178.87799
123, 591.91816, 0, -190.59139
124, 497.32652, 0, -204.2838
125, 403.04156, 0, -219.94925
126, 287.9092, 0, -241.84092
127, 191.12471, 0, -262.62444
128, 123.54333, 0, -278.44335
129, 83.088128, 0, 48.087036
130, 47.82577, 0, 83.238787
131, -0.3015924, 0, 95.999526
132, -48.087036, 0, 83.088128
133, -83.238787, 0, 47.82577
134, -83.088128, 0, -48.087036
135, -48.087036, 0, -83.088128
136, -0.3015924, 0, -95.999526
137, 47.82577, 0, -83.238787
138, 83.238787, 0, -47.82577
139, 673.86016, 0, 60.108795
140, 630.1088, 0, 103.86016
141, 570, 0, 120
142, 510.21779, 0, 104.04848
143, 465.95152, 0, 59.782213
144, 466.13984, 0, -60.108795
145, 510.21779, 0, -104.04848
146, 570.37699, 0, -119.99941
147, 630.1088, 0, -103.86016
148, 674.04848, 0, -59.782213
149, 977.89512, 0, 45.081596
150, 944.83666, 0, 78.036363
151, 899.71726, 0, 89.999556
152, 854.9184, 0, 77.89512
153, 821.96364, 0, 44.836659
154, 821.96364, 0, -44.836659
155, 854.42987, 0, -77.610328
156, 899.15178, 0, -89.996003
157, 945.81373, 0, -77.466782
158, 978.17684, 0, -44.59128
159, 26.058945, 0, -213.13624
160, 15.35229, 0, -202.22584
161, 0.18849432, 0, -198.00059
162, -15.433186, 0, -202.2742
163, -26.105513, 0, -213.21818
164, -25.96504, 0, -243.0272
165, -14.945553, 0, -254.01212
166, 0.094247625, 0, -257.99985
167, 15.027199, 0, -253.96504
168, 26.012121, 0, -242.94555
169, -132.23446, 0, -168.95457
170, -132.23446, 0, -153.48612
171, -139.9406, 0, -140.07389
172, -153.30415, 0, -132.28362
173, -168.77229, 0, -132.18643
174, -190.30114, 0, -153.85097
175, -190.10676, 0, -169.31819
176, -182.23268, 0, -182.63253
177, -168.86347, 0, -190.23039
178, -153.3951, 0, -190.1818
179, -212.9728, 0, -25.96504
180, -202.03496, 0, -15.027199
181, -198, 0, -2.4982734e-14
182, -201.98788, 0, 14.945553
183, -212.8913, 0, 25.917703
184, -243.0272, 0, 25.96504
185, -254.05895, 0, 14.86376
186, -257.99985, 0, -0.094247625
187, -253.9177, 0, -15.108696
188, -242.94555, 0, -26.012121
189, -168.95457, 0, 132.23446
190, -153.48612, 0, 132.23446
191, -139.9406, 0, 140.07389
192, -132.23446, 0, 153.48612
193, -132.2589, 0, 169.04559
194, -153.48612, 0, 190.20624
195, -169.04559, 0, 190.1818
196, -182.43355, 0, 182.43355
197, -190.20624, 0, 168.95457
198, -190.1818, 0, 153.3951
199, -25.96504, 0, 212.9728
200, -14.945553, 0, 201.98788
201, 0.094247625, 0, 198.00015
202, 15.027199, 0, 202.03496
203, 26.012121, 0, 213.05445
204, 26.012121, 0, 242.94555
205, 14.86376, 0, 254.05895
206, -0.094247625, 0, 257.99985
207, -15.027199, 0, 253.96504
208, -26.058945, 0, 242.86376
209, 1169.52, 0, -60
210, 1229.8911, 0, 52.024242
211, 1251.8354, 0, 30.217392
212, 1259.9997, 0, 0.18849525
213, 1252.1179, 0, -29.72752
214, 1230.3801, 0, -51.740219
215, 1173.36, 0, 60
216, 1109.9456, 0, -51.93008
217, 1088.0699, 0, -30.054398
218, 1080, 0, -3.6738191e-15
219, 1087.9758, 0, 29.891106
220, 1110.1089, 0, 52.024242
221, 73.846154, 28.44, 290.76923
222, 37.397526, 60, -297.65992
223, 5.83529, 60, -299.94324
224, -23.615886, 60, -299.06904
225, -51.764279, 60, -295.50035
226, -93.041053, 60, -285.20758
227, -133.42563, 60, -268.69611
228, -167.38212, 60, -248.96431
229, -192.67573, 60, -229.94795
230, -216.58237, 60, -207.58631
231, -237.24369, 60, -183.61762
232, -256.97066, 60, -154.80982
233, -276.70784, 60, -115.89984
234, -290.59251, 60, -74.538522
235, -297.96826, 60, -34.855621
236, -299.98212, 60, -3.2750463
237, -298.75938, 60, 27.254962
238, -291.64668, 60, 70.300895
239, -276.28424, 60, 116.90601
240, -253.52955, 60, 160.38319
241, -234.54591, 60, 187.05138
242, -216.58237, 60, 207.58631
243, -193.51124, 60, 229.24528
244, -165.56574, 60, 250.17591
245, -125.54789, 60, 272.46601
246, -73.114852, 60, 290.95398
247, -30.139634, 60, 298.48216
248, 0.37713894, 60, 299.99976
249, 31.975694, 60, 298.29106
250, 1131.7316, 60, -150.50938
251, 1070.3027, 60, -151.83877
252, 997.52917, 60, -154.48246
253, 928.2144, 60, -158.08008
254, 871.44494, 60, -161.81289
255, 807.92389, 60, -166.83136
256, 696.95247, 60, -177.74059
257, 599.81335, 60, -189.53961
258, 502.9488, 60, -203.41348
259, 395.19961, 60, -221.34356
260, 275.64755, 60, -244.353
261, 183.35739, 60, -264.38762
262, 121.33166, 60, -278.97935
263, 1265.9909, 60, 134.70414
264, 1320.5162, 60, 89.307576
265, 1347.8467, 60, 25.325017
266, 1345.1696, 60, -37.759732
267, 1316.1755, 60, -94.885524
268, 1263.4402, 60, -135.92403
269, 124.64927, 60, 278.17576
270, 193.34451, 60, 262.12316
271, 295.71562, 60, 240.25979
272, 420.97504, 60, 216.81355
273, 527.69951, 60, 199.66719
274, 622.38096, 60, 186.61028
275, 720.70914, 60, 175.17525
276, 814.7263, 60, 166.25136
277, 887.33565, 60, 160.69655
278, 960.02421, 60, 156.29815
279, 1055.5173, 60, 152.28202
280, 1130.5939, 60, 150.5265
281, 132.7847, 60, -69.772662
282, 90.063034, 60, -119.9527
283, 50.367058, 60, -141.29105
284, 15.523042, 60, -149.19462
285, -14.585324, 60, -149.28921
286, -49.478312, 60, -141.60472
287, -84.701843, 60, -123.7966
288, -112.20447, 60, -99.549771
289, -133.86426, 60, -67.678363
290, -146.97826, 60, -29.956497
291, -146.6894, 60, 31.340384
292, -131.67237, 60, 71.849745
293, -112.82774, 60, 98.842809
294, -89.307576, 60, 120.51621
295, -60.004371, 60, 137.47536
296, -22.999618, 60, 148.22624
297, 7.5366477, 60, 149.81054
298, 40.035298, 60, 144.55855
299, 85.478002, 60, 123.26196
300, 130.06061, 60, 74.727766
301, 673.86016, 60, 60.108795
302, 630.1088, 60, 103.86016
303, 570, 60, 120
304, 510.21779, 60, 104.04848
305, 465.95152, 60, 59.782213
306, 466.13984, 60, -60.108795
307, 510.21779, 60, -104.04848
308, 570.37699, 60, -119.99941
309, 630.1088, 60, -103.86016
310, 674.04848, 60, -59.782213
311, 977.89512, 60, 45.081596
312, 944.83666, 60, 78.036363
313, 899.71726, 60, 89.999556
314, 854.9184, 60, 77.89512
315, 821.96364, 60, 44.836659
316, 821.96364, 60, -44.836659
317, 854.42987, 60, -77.610328
318, 899.15178, 60, -89.996003
319, 945.81373, 60, -77.466782
320, 978.17684, 60, -44.59128
321, 26.012121, 60, -213.05445
322, 15.108696, 60, -202.0823
323, -0.28273915, 60, -198.00133
324, -15.190044, 60, -202.12989
325, -26.058945, 60, -213.13624
326, -25.96504, 60, -243.0272
327, -14.945553, 60, -254.01212
328, -1.8369095e-15, 60, -258
329, 15.027199, 60, -253.96504
330, 26.012121, 60, -242.94555
331, -132.23446, 60, -168.95457
332, -132.2589, 60, -153.3951
333, -140.07389, 60, -139.9406
334, -153.48612, 60, -132.23446
335, -169.04559, 60, -132.2589
336, -190.20624, 60, -153.48612
337, -190.1818, 60, -169.04559
338, -182.43355, 60, -182.43355
339, -168.95457, 60, -190.20624
340, -153.3951, 60, -190.1818
341, -212.9728, 60, -25.96504
342, -201.98788, 60, -14.945553
343, -198.00015, 60, 0.094247625
344, -202.03496, 60, 15.027199
345, -213.05445, 60, 26.012121
346, -243.0272, 60, 25.96504
347, -254.01212, 60, 14.945553
348, -258, 60, -2.1308915e-14
349, -253.96504, 60, -15.027199
350, -242.94555, 60, -26.012121
351, -168.95457, 60, 132.23446
352, -153.3951, 60, 132.2589
353, -140.00714, 60, 140.00714
354, -132.23446, 60, 153.48612
355, -132.2589, 60, 169.04559
356, -153.48612, 60, 190.20624
357, -169.04559, 60, 190.1818
358, -182.43355, 60, 182.43355
359, -190.20624, 60, 168.95457
360, -190.1818, 60, 153.3951
361, -25.96504, 60, 212.9728
362, -14.945553, 60, 201.98788
363, 0.094247625, 60, 198.00015
364, 15.027199, 60, 202.03496
365, 26.012121, 60, 213.05445
366, 25.96504, 60, 243.0272
367, 14.86376, 60, 254.05895
368, -0.18849432, 60, 257.99941
369, -15.108696, 60, 253.9177
370, -26.012121, 60, 242.94555
371, 1169.52, 60, -60
372, 1109.9456, 60, -51.93008
373, 1088.0699, 60, -30.054398
374, 1080, 60, -3.6738191e-15
375, 1087.9758, 60, 29.891106
376, 1110.1089, 60, 52.024242
377, 1171.98, 60, 60
378, 1229.8911, 60, 52.024242
379, 1251.8354, 60, 30.217392
380, 1259.9997, 60, 0.18849525
381, 1252.1179, 60, -29.72752
382, 1230.3801, 60, -51.740219
383, 132.24558, 360, -70.789173
384, 84.079962, 360, -124.21981
385, 150, 172.2, 1.8369702e-14
386, 150, 274.2, 1.8369702e-14
387, -150, 92.1, -1.8369702e-14
388, -150, 142.2, -1.8369702e-14
389, -150, 212.4, -1.8369702e-14
390, -150, 298.8, -1.8369702e-14
391, -89.355535, 360, -120.48066
392, -136.00327, 360, -63.270131
393, -86.252069, 360, -42.149504
394, -59.090924, 360, -75.658857
395, -59.193835, 360, 75.578369
396, -86.309351, 360, 42.032082
397, -140.34733, 360, 52.939847
398, -113.76308, 360, 97.764825
399, -71.180138, 360, 132.03556
400, 86.252069, 360, 42.149504
401, 59.090924, 360, 75.658857
402, 59.501911, 360, -75.336065
403, 86.423436, 360, -41.797005
404, 84.614714, 360, 123.85617
405, 132.44849, 360, 70.408791
406, 96, 308.88, -2.094146e-14
407, 96, 224.28, -2.094146e-14
408, 96, 129.24, -2.094146e-14
409, 96, 53.64, -2.094146e-14
410, -96, 303.84, 0
411, -96, 226.44, 0
412, -96, 127.44, 0
413, -96, 60.84, 0
414, 30, 44.94, -228
415, 30, 29.94, -228
416, 30, 15, -228
417, -30, 44.94, -228
418, -30, 29.94, -228
419, -30, 15, -228
420, -140.00714, 44.94, -182.43355
421, -140.00714, 29.94, -182.43355
422, -140.00714, 15, -182.43355
423, -182.43355, 44.94, -140.00714
424, -182.43355, 29.94, -140.00714
425, -182.43355, 15, -140.00714
426, -228, 44.94, -30
427, -228, 29.94, -30
428, -228, 15, -30
429, -228, 44.94, 30
430, -228, 29.94, 30
431, -228, 15, 30
432, -182.43355, 44.94, 140.00714
433, -182.43355, 29.94, 140.00714
434, -182.43355, 15, 140.00714
435, -140.00714, 44.94, 182.43355
436, -140.00714, 29.94, 182.43355
437, -140.00714, 15, 182.43355
438, -30, 44.94, 228
439, -30, 29.94, 228
440, -30, 15, 228
441, 30, 44.94, 228
442, 30, 29.94, 228
443, 30, 15, 228
444, 1140, 29.94, -60
445, 1200, 29.94, -60
446, 1140, 29.94, 60
447, 1200, 29.94, 60
448, 26.872886, 0, -279.16475
449, -40.73737, 0, -276.4738
450, -72.918358, 0, -261.28918
451, -117.37935, 0, -245.73162
452, -170.78163, 0, -222.48221
453, -217.44007, 0, -177.68455
454, -225.14172, 0, -150.74284
455, -239.27163, 0, -121.57423
456, -271.1336, 0, -59.179677
457, -267.53268, 0, 47.134014
458, -254.51368, 0, 79.385208
459, -226.03645, 0, 156.1812
460, -163.60583, 0, 223.95743
461, -133.86834, 0, 237.81228
462, 94.706715, 0, 244.2988
463, 149.06435, 0, 206.85202
464, 333.90271, 0, 137.28276
465, 715.42813, 0, 107.22025
466, 1307.0077, 0, -2.8329042
467, 1101.3238, 0, -94.096935
468, 1020.1008, 0, -86.902982
469, 751.22394, 0, -108.71452
470, 434.56986, 0, -125.76842
471, 328.58315, 0, -134.78689
472, 222.03936, 0, -177.09248
473, 149.70443, 0, -200.56756
474, 83.07717, 0, -256.25526
475, 137.21604, 0, 37.833186
476, 98.580475, 0, 100.76104
477, 38.452797, 0, 124.14799
478, -37.601916, 0, 121.87947
479, -95.439719, 0, 88.251579
480, -133.41481, 0, 22.07127
481, -132.80863, 0, -26.30427
482, -87.363533, 0, -88.224812
483, -23.0716, 0, -132.39573
484, 42.3823, 0, -135.14662
485, 97.078508, 0, -98.394747
486, 135.8485, 0, -39.526369
487, 433.7406, 0, 128.38068
488, 402.70238, 0, 54.082993
489, 389.73977, 0, -40.654369
490, 1021.0772, 0, 33.452147
491, 752.48158, 0, 33.773366
492, 764.59472, 0, -50.80312
493, 1024.5227, 0, -24.36551
494, 42.880878, 0, -218.02582
495, 32.200247, 0, -197.71259
496, 13.598682, 0, -185.75504
497, -8.9847306, 0, -184.22474
498, -33.30479, 0, -194.10328
499, -43.055516, 0, -218.60335
500, -40.080433, 0, -240.1304
501, -29.413215, 0, -259.65016
502, -10.0427, 0, -266.36105
503, 6.7993733, 0, -272.04951
504, 30.25467, 0, -258.73481
505, 41.46332, 0, -241.08233
506, -124.67223, 0, -181.39549
507, -115.22392, 0, -159.58704
508, -123.5789, 0, -137.77914
509, -139.49599, 0, -122.03258
510, -161.99916, 0, -116.50646
511, -185.04379, 0, -122.98404
512, -201.07315, 0, -141.01762
513, -204.56865, 0, -162.59353
514, -199.18787, 0, -183.93406
515, -183.59944, 0, -202.59125
516, -160.87034, 0, -205.05802
517, -138.21697, 0, -199.86848
518, -216.73193, 0, -43.366567
519, -196.47651, 0, -30.56631
520, -184.30771, 0, -11.072833
521, -184.84049, 0, 10.842596
522, -196.65431, 0, 30.186382
523, -219.14304, 0, 44.677986
524, -241.31017, 0, 40.503755
525, -256.74513, 0, 29.668284
526, -273.66131, 0, 14.100277
527, -270.4246, 0, -12.22035
528, -257.28499, 0, -28.669389
529, -240.50199, 0, -40.339436
530, -183.25703, 0, 124.32109
531, -158.77921, 0, 113.28661
532, -135.50674, 0, 124.02481
533, -121.44905, 0, 140.45103
534, -115.28692, 0, 163.74775
535, -125.80764, 0, 183.28957
536, -139.99945, 0, 196.65219
537, -158.67965, 0, 204.73139
538, -183.22107, 0, 203.02158
539, -199.50775, 0, 183.97272
540, -204.79696, 0, 163.01921
541, -202.5474, 0, 139.92421
542, -41.513794, 0, 213.56198
543, -28.580856, 0, 196.5713
544, -9.8919141, 0, 187.9751
545, 10.307014, 0, 187.26499
546, 29.486132, 0, 196.00229
547, 42.41793, 0, 213.65186
548, 44.593541, 0, 237.50312
549, 34.332305, 0, 257.65006
550, 14.840179, 0, 274.35568
551, -14.655838, 0, 274.26147
552, -33.923853, 0, 257.21702
553, -43.971949, 0, 237.06122
554, 1189.9132, 0, -92.719841
555, 1225.1316, 0, 91.618279
556, 1265.1039, 0, 68.36514
557, 1291.9259, 0, 36.086963
558, 1279.6044, 0, -26.872261
559, 1267.2576, 0, -66.917522
560, 1228.3736, 0, -91.074909
561, 1154.9104, 0, 101.48437
562, 1190.0023, 0, 91.288357
563, 1067.4092, 0, -54.435737
564, 1061.8989, 0, -19.184615
565, 1056.0105, 0, 15.75139
566, 1067.8404, 0, 63.61337
567, 1111.9429, 0, 93.354896
568, 1013.8713, 0, 89.198562
569, -15.033437, 0, -281.29651
570, -257.10642, 0, -87.799483
571, -276.29345, 0, -31.465243
572, -232.50236, 0, 117.48375
573, -217.19513, 0, 178.53718
574, -92.852537, 0, 244.04961
575, 226.7758, 0, 172.46498
576, 1150.3744, 0, -99.919572
577, -146.53882, 0, -224.94151
578, -84.857867, 0, -224.91603
579, -221.71686, 0, 72.260176
580, 42.897836, 0, 276.29051
581, 254.33306, 0, 73.74176
582, -111.27119, 0, 216.14413
583, 1307.211, 0, -44.165146
584, 61.690443, 0, 255.1081
585, -218.20161, 0, -92.259509
586, 95.736556, 0, -210.62825
587, 238.62053, 0, -96.395031
588, 163.52693, 0, -115.50333
589, -2.7402504, 0, 129.35682
590, -75.512899, 0, 120.02282
591, -124.86323, 0, 64.236587
592, -121.60858, 0, -71.928137
593, -72.784069, 0, -125.68387
594, 333.09008, 0, 37.902842
595, -129.32614, 0, 98.679819
596, 52.382228, 0, -265.27554
597, 173.3747, 0, 108.9964
598, 93.318885, 0, 194.66544
599, 104.5243, 0, -153.09779
600, 201.55151, 0, -8.0034058
601, 786.28324, 0, 88.178558
602, 56.8724, 0, -200.03195
603, -103.81318, 0, -179.60403
604, 36.965571, 0, -174.67505
605, 6.529576, 0, -162.13691
606, -22.560256, 0, -166.96618
607, -59.274273, 0, -205.03757
608, -60.140206, 0, -233.60174
609, 62.78896, 0, -231.02438
610, -191.44959, 0, -50.655974
611, -102.51416, 0, -138.53139
612, -114.74749, 0, -111.60055
613, -146.58408, 0, -97.095711
614, -182.00529, 0, -99.397122
615, -209.99809, 0, -119.52419
616, -118.07123, 0, -196.90141
617, -181.26962, 0, 101.8126
618, -170.63716, 0, -30.829987
619, -161.38009, 0, -0.8383732
620, -171.35947, 0, 28.267854
621, -193.04717, 0, 50.636811
622, -239.86425, 0, 58.266812
623, -239.92206, 0, -62.641098
624, -49.858393, 0, 187.10159
625, -109.41145, 0, 119.69486
626, -96.453728, 0, 144.64567
627, -106.41763, 0, 189.09215
628, -123.59988, 0, 201.18387
629, -201.85377, 0, 117.11865
630, -22.976972, 0, 177.83131
631, -1.2517552, 0, 171.19785
632, 24.203345, 0, 174.32074
633, 53.848849, 0, 188.42241
634, 66.324246, 0, 221.49188
635, -61.068881, 0, 254.22929
636, -62.861348, 0, 221.40447
637, -42.189905, 0, 276.11529
638, -161.36973, 0, -65.487126
639, -65.700668, 0, 157.92554
640, -138.26854, 0, 215.69501
641, -119.52269, 0, -218.33253
642, -88.150875, 0, -159.1837
643, -206.91522, 0, 95.563082
644, -213.02172, 0, -64.679191
645, -52.903681, 0, -166.33207
646, 68.175188, 0, -173.73174
647, 13.391204, 0, 151.33831
648, -159.43833, 0, 53.722064
649, -25.367438, 0, 154.04293
650, -155.90985, 0, 85.090538
651, -92.001404, 0, 170.01668
652, -49.281164, 0, -255.08152
653, 119.94766, 0, 153.69963
654, 75.71246, 0, 153.6715
655, -257.80897, 0, -45.776134
656, -81.466815, 0, 196.35539
657, 287.97265, 0, -30.122053
658, -79.242027, 0, -188.713
659, -186.44061, 0, 74.666686
660, 41.167196, 0, 157.63404
661, -192.80874, 0, -76.022433
662, -99.285527, 0, -202.17366
663, 15.946031, 29.863895, -299.57591
664, -11.279459, 30.043013, -299.78788
665, -37.69503, 29.943278, -297.62239
666, -74.980894, 29.926298, -290.47868
667, -180.1235, 29.907585, -239.90732
668, -205.06091, 30.039753, -218.97493
669, -227.43263, 29.963469, -195.63844
670, -247.2169, 30.115955, -169.95236
671, -267.72664, 30.0044, -135.36043
672, -284.24104, 29.967921, -95.95328
673, -294.80697, 30.734146, -55.577426
674, -299.31107, 30.73401, -20.319582
675, -299.75784, 30.140475, 12.051502
676, -296.35307, 29.707997, 46.63538
677, -286.17837, 29.99388, 90.010771
678, -266.75675, 29.876544, 137.26193
679, -245.77063, 29.986334, 172.03719
680, -227.20053, 29.98287, 195.90793
681, -207.00535, 29.917496, 217.13771
682, -180.61055, 29.978136, 239.54087
683, -151.63464, 29.814706, 258.85698
684, -14.150561, 29.846092, 299.66608
685, 19.099818, 29.127457, 299.39138
686, -152.12617, 29.631149, -258.56842
687, -114.73242, 29.919139, -277.19392
688, -45.039245, 30.06948, 296.59984
689, 98.804671, 28.808127, 284.50522
690, 21.298452, 60, -280.89581
691, -30.024462, 60, -278.16488
692, -89.95835, 60, -242.23345
693, -164.71762, 60, -223.45963
694, -217.10953, 60, -177.66808
695, -236.39964, 60, -118.92225
696, -265.02604, 60, -51.127207
697, -254.74563, 60, 79.61399
698, -224.53638, 60, 158.97149
699, -164.87869, 60, 224.36346
700, -89.234625, 60, 243.78672
701, 1101.2442, 60, -93.621706
702, 330.18588, 60, -148.33471
703, 143.62514, 60, -211.57002
704, 88.711837, 60, 245.91742
705, 237.94006, 60, 170.81538
706, 755.31304, 60, 104.55053
707, 197.52961, 60, -45.885415
708, 157.95248, 60, -139.12543
709, 101.49101, 60, -171.94282
710, -6.3171112, 60, -169.24115
711, -85.772293, 60, -165.98898
712, -110.54061, 60, -123.93555
713, -152.46045, 60, -95.02847
714, -168.12555, 60, -59.145147
715, -172.26785, 60, -20.154146
716, -168.89526, 60, 17.747696
717, -175.45564, 60, 57.929999
718, -148.3018, 60, 90.958959
719, -112.02091, 60, 127.87757
720, -86.135268, 60, 150.90268
721, -55.163511, 60, 165.33952
722, -2.8545106, 60, 168.87601
723, 30.645767, 60, 171.24858
724, 91.322428, 60, 182.19148
725, 152.34881, 60, 164.71653
726, 219.48032, 60, 65.179213
727, 722.57727, 60, 49.362008
728, 688.26513, 60, 112.63515
729, 443.71075, 60, 131.49362
730, 400.82547, 60, 63.18493
731, 402.09383, 60, -66.107633
732, 439.54681, 60, -131.135
733, 732.46617, 60, -30.24966
734, 1016.2069, 60, 30.569913
735, 1004.3161, 60, 93.194192
736, 809.18497, 60, 89.826631
737, 775.17599, 60, 34.739123
738, 780.18019, 60, -27.384207
739, 1025.9925, 60, -23.550539
740, 43.883731, 60, -223.00468
741, 29.578595, 60, -193.35401
742, 9.1466358, 60, -186.04921
743, -11.370352, 60, -188.20958
744, -30.879685, 60, -200.31699
745, -40.581536, 60, -219.2014
746, -41.827241, 60, -240.32202
747, -30.870548, 60, -257.69476
748, -11.852648, 60, -267.74234
749, 7.8304594, 60, -268.95006
750, 29.13781, 60, -259.59873
751, 40.160567, 60, -242.97588
752, -126.76638, 60, -183.74288
753, -115.77516, 60, -166.68275
754, -126.86682, 60, -134.21432
755, -143.91806, 60, -122.11507
756, -164.64806, 60, -118.25808
757, -184.09684, 60, -125.81584
758, -199.27627, 60, -140.84087
759, -204.37541, 60, -162.20027
760, -199.10732, 60, -183.96996
761, -182.66758, 60, -203.03662
762, -160.34081, 60, -203.72801
763, -140.64476, 60, -196.77069
764, -216.4118, 60, -41.458872
765, -197.15859, 60, -29.449285
766, -188.98319, 60, -12.538585
767, -185.03315, 60, 6.724093
768, -193.05874, 60, 29.787081
769, -214.41692, 60, 46.549605
770, -236.92767, 60, 41.715141
771, -256.74759, 60, 32.452551
772, -273.53066, 60, 14.12562
773, -273.49637, 60, -17.190092
774, -255.59322, 60, -30.73508
775, -239.70438, 60, -41.534234
776, -182.65615, 60, 121.97874
777, -157.63945, 60, 114.03083
778, -136.21217, 60, 127.25448
779, -124.11141, 60, 142.88126
780, -119.46318, 60, 161.76276
781, -122.84844, 60, 184.54147
782, -140.80221, 60, 197.08477
783, -160.63569, 60, 204.41097
784, -187.13845, 60, 201.68063
785, -196.99394, 60, 180.3658
786, -204.34203, 60, 163.84974
787, -202.80486, 60, 139.30159
788, -45.002436, 60, 215.82176
789, -30.400805, 60, 196.45122
790, -11.331551, 60, 187.00517
791, 11.113328, 60, 186.27802
792, 30.898714, 60, 196.70362
793, 44.896764, 60, 217.90493
794, 41.423549, 60, 241.74792
795, 30.855939, 60, 259.57273
796, 13.475677, 60, 274.71465
797, -14.715404, 60, 273.99852
798, -32.094562, 60, 258.10829
799, -42.068754, 60, 239.40298
800, 1192.3315, 60, -93.330243
801, 1151.4173, 60, -99.754024
802, 1067.6334, 60, -53.550702
803, 1061.152, 60, -18.192976
804, 1055.2885, 60, 19.518148
805, 1080.0737, 60, 60.211248
806, 1113.9609, 60, 86.602752
807, 1154.7451, 60, 100.79357
808, 1190.0325, 60, 90.736347
809, 1227.2711, 60, 90.02657
810, 1267.6832, 60, 63.174095
811, 1281.4011, 60, 17.722358
812, 1281.241, 60, -18.804906
813, 1268.3283, 60, -57.34271
814, 1236.4222, 60, -91.376807
815, 781.41593, 60, -88.840452
816, 1024.3816, 60, -86.754085
817, -4.9492942, 60, -283.08092
818, -56.140327, 60, -260.58142
819, -132.19122, 60, -235.19369
820, -224.42582, 60, -150.09266
821, -250.53338, 60, -84.594132
822, -274.282, 60, 47.069894
823, -232.34901, 60, 123.34735
824, -213.16176, 60, 184.8231
825, -130.26386, 60, 234.0193
826, 706.46773, 60, -96.143038
827, 216.31033, 60, -188.9886
828, 90.807788, 60, -231.48453
829, 1312.9211, 60, -2.5647441
830, 1305.9677, 60, -44.411792
831, 334.76132, 60, 137.53498
832, 852.85499, 60, 120.54791
833, 60.03219, 60, -185.64056
834, 381.15536, 60, -2.4448218
835, 43.297272, 60, -205.4668
836, -44.414758, 60, -166.41121
837, -202.69213, 60, -85.683568
838, -39.582539, 60, 276.40047
839, 1306.8746, 60, 39.683638
840, 1070.4299, 60, 103.48575
841, -57.809942, 60, 257.14414
842, 58.875475, 60, -236.575
843, 52.539036, 60, -266.29554
844, 27.760752, 60, -170.62788
845, -78.43753, 60, 182.10119
846, 259.7993, 60, -17.37764
847, -206.74638, 60, -120.18633
848, -61.406001, 60, -228.87241
849, -123.62287, 60, -204.93282
850, -228.15976, 60, -62.553297
851, -109.00452, 60, -185.17318
852, -232.68418, 60, 60.995833
853, -202.40895, 60, 112.00945
854, -195.47053, 60, -52.433318
855, -107.79333, 60, 151.14322
856, -101.94585, 60, 172.3286
857, -126.23633, 60, 207.06831
858, -61.758991, 60, 233.01521
859, -178.60749, 60, 95.585895
860, 53.501141, 60, 195.31282
861, 63.757659, 60, 243.22123
862, 50.366745, 60, 261.53464
863, -52.040762, 60, 191.35285
864, 247.7023, 60, -102.01786
865, 38.747935, 60, 278.05886
866, -98.422786, 60, -209.2852
867, -213.92337, 60, 80.84571
868, 1044.087, 60, 62.728907
869, 69.390398, 60, 215.97944
870, -72.121763, 60, 211.0247
871, -251.65503, 60, 53.150801
872, 316.33932, 60, 36.961013
873, -108.67399, 60, -145.52612
874, -133.41451, 60, 110.15836
875, -28.741305, 60, 174.63041
876, -70.865868, 60, -197.38939
877, -128.94787, 60, -113.73376
878, 322.77303, 60, -51.040164
879, -50.752056, 60, -207.15397
880, -183.53988, 60, -107.40354
881, -144.1381, 60, -214.59994
882, -144.12108, 60, 214.73977
883, -101.27045, 60, 205.2715
884, -26.673834, 60, -181.04873
885, -45.083673, 60, -189.27581
886, 60.335594, 60, -215.5247
887, 100.24557, 304.71945, -111.58327
888, 124.40187, 245.25522, -83.810353
889, 70.77552, 106.82139, -132.25289
890, 0.16826364, 87.305666, -149.99991
891, -70.730247, 98.025653, -132.2771
892, -124.77803, 88.176568, -83.249286
893, -134.71401, 175.10772, -65.970719
894, -128.45661, 276.40972, -77.45256
895, 8.1735475, 248.31006, -149.77714
896, 114.79297, 139.32317, -96.553478
897, -142.85059, 105.8181, -45.757059
898, 58.706758, 317.33115, -138.03448
899, 32.6339, 101.02601, -146.40706
900, -32.466791, 94.304028, -146.44421
901, -101.77899, 96.368753, -110.18637
902, 62.379965, 264.00422, -136.41386
903, -46.883763, 248.97149, -142.48478
904, -83.306161, 286.88102, -124.74006
905, 48.643684, 178.33015, -141.89359
906, -2.5974, 134.31495, -149.97751
907, -93.051172, 150.01439, -117.64982
908, -122.03038, 126.43262, -87.22721
909, -48.953787, 135.0005, -141.78691
910, -33.255442, 189.26775, -146.26714
911, -96.538841, 217.70052, -114.80528
912, 4.6650397, 260.90386, -95.886586
913, 72.699999, 315.56558, -62.695376
914, 62.396118, 169.83718, -72.957004
915, 68.214456, 70.310342, -67.548412
916, -73.179473, 45.166803, -62.135052
917, 20.996416, 49.203095, -93.675773
918, -82.768638, 257.32375, -48.634891
919, -72.323736, 98.330343, -63.129052
920, -71.682743, 308.75357, -63.855966
921, 56.537082, 254.87732, -77.585813
922, -30.898545, 54.718646, -90.891583
923, -65.018095, 176.13593, -70.630357
924, -39.790669, 254.38491, -87.36534
925, -4.2303126, 116.17001, -95.906749
926, 4.2697797, 206.97062, -95.905
927, -15.220205, 237.64247, 94.785787
928, -74.972101, 262.43355, 59.959853
929, -77.212691, 177.27023, 57.045599
930, -78.657706, 93.280215, 55.036037
931, 71.949118, 41.158024, 63.55568
932, -34.979265, 60.870644, 89.400509
933, 69.767667, 184.83495, 65.942949
934, 71.100647, 99.190077, 64.503473
935, 74.948826, 288.38772, 59.988944
936, -75.289821, 317.45196, 59.560413
937, 28.343335, 55.143416, 91.720529
938, 37.919734, 244.26119, 88.193502
939, -36.74366, 139.96277, 88.689929
940, 18.600716, 114.99538, 94.180748
941, 19.555862, 186.81206, 93.987064
942, -132.34863, 311.11467, 70.596318
943, -97.477891, 296.61151, 114.00904
944, -142.9305, 106.24061, 45.506826
945, -139.3475, 171.11792, 55.518232
946, -125.19176, 91.520018, 82.625797
947, -75.996859, 95.366081, 129.32315
948, -6.4602035, 103.15901, 149.86082
949, 62.65975, 106.9967, 136.28557
950, 124.74419, 209.29274, 83.299986
951, 111.88431, 289.77133, 99.909469
952, -1.5562156, 261.26184, 149.99193
953, -133.45133, 247.34765, 68.489005
954, -103.38827, 95.178731, 108.6778
955, -41.471525, 99.188671, 144.15309
956, 26.872986, 95.218272, 147.57318
957, 106.06872, 116.86323, 106.06332
958, 140.9056, 123.54506, 51.435516
959, 61.172761, 309.40778, 136.95946
960, 50.020022, 240.67238, 141.41428
961, -47.488635, 262.7961, 142.28433
962, -55.092514, 314.80159, 139.51636
963, -86.473905, 188.85972, 122.56534
964, -93.061856, 129.14589, 117.64137
965, -121.06489, 134.30678, 88.562364
966, 74.452995, 166.1237, 130.21809
967, -12.036274, 208.22454, 149.51631
968, 23.604837, 148.29334, 148.13106
969, -26.42529, 148.95024, 147.654
970, -63.262025, 132.77263, 136.00704
971, 22.751494, 14.019665, -208.44573
972, -6.5781853, 15.485378, -198.73009
973, 28.179871, 36.151003, -217.70948
974, 20.021211, 49.14837, -205.65831
975, 8.2447201, 46.170241, -199.15516
976, -6.9277271, 45.50401, -198.81085
977, -20.063386, 45.447836, -205.69618
978, -27.843849, 45.000234, -216.83219
979, -27.582236, 18.771694, -216.20084
980, 9.3871061, 15.61873, -199.50645
981, -19.915996, 16.111487, -205.56447
982, 27.577772, 24.675848, -216.19041
983, 27.203799, 47.63283, -215.35274
984, 2.0037047, 30.961361, -198.06699
985, -24.577687, 31.256054, -210.79717
986, 19.352337, 33.042144, -205.0765
987, -13.283473, 30.770768, -201.10113
988, -22.69298, 14.027359, -247.62215
989, 6.4020267, 15.274407, -257.30894
990, -28.208273, 36.195897, -238.21241
991, -20.020995, 49.19846, -250.34188
992, -8.2324569, 46.36533, -256.84834
993, 7.0310949, 45.386088, -257.16443
994, 20.749212, 44.782742, -249.66726
995, 28.144295, 49.322842, -238.38743
996, 27.898648, 36.473866, -239.03021
997, 27.574797, 21.025294, -239.81654
998, -9.3101046, 15.27346, -256.5188
999, 19.575122, 15.767261, -250.73356
1000, -27.60353, 24.698007, -239.74926
1001, -27.207686, 47.670897, -240.6389
1002, 12.604619, 30.329284, -255.22358
1003, -19.714391, 33.089966, -250.61289
1004, 22.474861, 29.684302, -247.8716
1005, -1.8341903, 30.81135, -257.94388
1006, -131.29942, 14.046513, -163.39708
1007, -144.85025, 15.359092, -136.08034
1008, -134.02271, 36.185884, -173.88086
1009, -131.26786, 49.168349, -159.53255
1010, -134.97719, 46.132399, -146.6843
1011, -145.49612, 45.345315, -135.6714
1012, -160.51832, 44.781985, -131.22856
1013, -173.76202, 49.317514, -133.9677
1014, -173.10808, 36.463953, -133.67617
1015, -172.28001, 21.016148, -133.33336
1016, -134.40667, 15.598479, -147.76572
1017, -158.81314, 15.788306, -131.31708
1018, -133.36928, 24.696487, -172.37016
1019, -133.03314, 47.656536, -171.49077
1020, -150.68969, 30.352504, -133.12933
1021, -131.31609, 33.053053, -158.82549
1022, -162.94267, 29.690541, -131.26983
1023, -138.42316, 30.890116, -141.71937
1024, -191.15487, 14.066885, -159.23941
1025, -177.53847, 15.407424, -186.39412
1026, -188.42261, 36.188319, -148.56978
1027, -191.17317, 49.175761, -162.90219
1028, -187.48369, 46.132614, -175.71989
1029, -177.04143, 45.337981, -186.70943
1030, -162.33985, 44.624912, -191.19945
1031, -148.40099, 49.383713, -188.34347
1032, -149.2708, 36.28502, -188.73776
1033, -149.8835, 21.336902, -188.9958
1034, -187.95094, 15.604975, -174.83929
1035, -163.92695, 16.002788, -191.098
1036, -189.08913, 24.699726, -150.1149
1037, -189.40754, 47.659335, -150.94989
1038, -171.7867, 30.382216, -189.29796
1039, -191.12249, 33.069523, -163.64151
1040, -159.51226, 29.71252, -191.17168
1041, -184.01592, 30.906234, -180.72322
1042, -208.3751, 14.046083, -22.690602
1043, -198.6596, 15.357962, 6.2562863
1044, -217.71899, 36.185295, -28.183344
1045, -205.62505, 49.167219, -19.984032
1046, -199.16304, 46.130119, -8.27224
1047, -198.81783, 45.343683, 6.9570725
1048, -206.30292, 44.782134, 20.718032
1049, -217.60087, 49.319016, 28.139974
1050, -216.93873, 36.467728, 27.886348
1051, -216.12511, 21.021951, 27.54972
1052, -199.51572, 15.592241, -9.4151959
1053, -205.1883, 15.790934, 19.484
1054, -216.18748, 24.6958, -27.576517
1055, -215.32967, 47.655965, -27.193063
1056, -200.70406, 30.351635, 12.447166
1057, -205.15654, 33.050983, -19.446752
1058, -208.05962, 29.693254, 22.413865
1059, -198.08894, 30.886, -2.3083166
1060, -247.68725, 14.024568, 22.636523
1061, -257.27306, 15.532168, -6.5641368
1062, -238.30775, 36.15808, 28.173576
1063, -250.37454, 49.16532, 19.984489
1064, -256.82969, 46.148144, 8.2975186
1065, -257.21596, 45.519881, -6.8137937
1066, -250.36695, 45.463527, -19.992992
1067, -239.20842, 45.007369, -27.827526
1068, -239.86629, 18.767937, -27.553422
1069, -256.53898, 15.641023, 9.2480467
1070, -250.51423, 16.109207, -19.826988
1071, -239.85203, 24.677247, 27.559562
1072, -240.67757, 47.643673, 27.189691
1073, -257.93226, 30.981058, 2.0148631
1074, -245.26583, 31.263822, -24.533468
1075, -250.94437, 33.057157, 19.32759
1076, -254.92851, 30.795635, -13.223294
1077, -163.38025, 14.045872, 131.2982
1078, -136.01701, 15.355978, 144.94792
1079, -173.87913, 36.18481, 134.02191
1080, -159.53497, 49.167658, 131.26773
1081, -146.69704, 46.122311, 134.97013
1082, -135.67058, 45.34578, 145.49745
1083, -131.22817, 44.78242, 160.53509
1084, -133.97032, 49.320561, 173.76769
1085, -133.6849, 36.472123, 173.12829
1086, -133.35708, 21.028394, 172.33962
1087, -147.70815, 15.585074, 134.43564
1088, -131.30712, 15.788444, 158.9402
1089, -172.36556, 24.69525, 133.36744
1090, -171.49096, 47.65593, 133.03321
1091, -133.10572, 30.349963, 150.75288
1092, -158.81734, 33.049067, 131.31674
1093, -131.27327, 29.694936, 163.00148
1094, -141.69239, 30.880532, 138.44626
1095, -159.10536, 14.026204, 191.1457
1096, -186.53126, 15.529734, 177.32493
1097, -148.58407, 36.158698, 188.42925
1098, -162.90638, 49.165871, 191.17293
1099, -175.73195, 46.148927, 187.47703
1100, -186.69174, 45.518536, 177.06989
1101, -191.17289, 45.460825, 162.90715
1102, -188.82438, 45.00427, 149.47227
1103, -189.09937, 18.762551, 150.14064
1104, -174.81583, 15.640552, 187.96287
1105, -191.15789, 16.099594, 163.15521
1106, -150.10523, 24.678459, 189.08527
1107, -150.95677, 47.644136, 189.41004
1108, -180.9373, 30.980312, 183.831
1109, -190.78002, 31.259277, 156.09923
1110, -163.76585, 33.057256, 191.11216
1111, -189.60275, 30.79115, 170.93832
1112, -22.669733, 14.044274, 208.351
1113, 6.3255162, 15.356385, 198.67445
1114, -28.182024, 36.184444, 217.71537
1115, -19.980637, 49.166186, 205.62202
1116, -8.2633207, 46.127949, 199.16049
1117, 6.9712912, 45.341639, 198.82122
1118, 20.727806, 44.78142, 206.31226
1119, 28.141543, 49.320785, 217.60512
1120, 27.891633, 36.472179, 216.95207
1121, 27.565836, 21.028381, 216.16257
1122, -9.3584689, 15.590622, 199.49703
1123, 19.543234, 15.787989, 205.23902
1124, -27.572785, 24.694322, 216.17877
1125, -27.192073, 47.655303, 215.32754
1126, 12.488172, 30.348504, 200.7228
1127, -19.43684, 33.049896, 205.1481
1128, 22.438857, 29.694202, 208.08775
1129, -2.2750593, 30.882916, 198.08639
1130, 22.34184, 12.251107, 248.02104
1131, -6.595749, 14.946694, 257.26595
1132, 27.175308, 40.628646, 240.70837
1133, 20.109212, 48.912718, 250.26252
1134, 8.1760877, 46.519254, 256.86437
1135, -6.7053472, 45.327893, 257.24104
1136, -19.938729, 45.347701, 250.41533
1137, -27.816984, 44.96349, 239.23456
1138, -27.546423, 18.721947, 239.88253
1139, 8.4486016, 13.134057, 256.78578
1140, -19.806379, 15.926988, 250.53236
1141, 26.39617, 26.044677, 242.2563
1142, 3.0263683, 29.987205, 257.84696
1143, 17.882507, 35.81647, 252.08767
1144, -24.477422, 31.158713, 245.3452
1145, 16.236678, 23.468051, 253.22638
1146, -12.976555, 30.44542, 255.04827
1147, 1099.3496, 29.994264, -44.131003
1148, 1082.1624, 29.999069, -15.962912
1149, 1082.1473, 29.999078, 15.908099
1150, 1099.3623, 29.994316, 44.142694
1151, 1240.5235, 29.994233, 44.247509
1152, 1257.7862, 29.999063, 16.148017
1153, 1257.9103, 29.999073, -15.696885
1154, 1240.8851, 29.994319, -43.913609
1155, 62.417904, 29.480164, -251.60786
1156, 46.682544, 23.941827, -191.70838
1157, 70.769644, 34.812282, -201.03751
1158, 39.951215, 37.713646, -172.08314
1159, 39.574669, 23.363617, -223.22715
1160, 10.693943, 29.902054, -159.31738
1161, -22.196233, 34.655873, -167.04786
1162, -32.492643, 37.156924, -191.47835
1163, -44.685987, 42.104949, -220.87591
1164, -61.118939, 34.546952, -250.07888
1165, -94.481792, 26.049461, -245.37442
1166, -49.138514, 28.651565, -271.76005
1167, 35.18959, 30.936267, -268.73804
1168, -110.8377, 20.550822, -158.21617
1169, -116.78513, 15.540847, -180.06125
1170, -130.40775, 32.422565, -125.212
1171, -134.90693, 33.650098, -219.66216
1172, -107.37058, 23.744742, -120.66116
1173, -172.88578, 39.201649, -118.75793
1174, -170.15308, 32.535946, -92.550869
1175, -232.25689, 29.628943, -139.369
1176, -199.90454, 36.942286, -110.07291
1177, -253.43856, 28.518453, -62.816241
1178, -218.86744, 28.059262, -42.238066
1179, -196.89093, 30.007072, -37.78491
1180, -178.44296, 32.268836, -2.7850434
1181, -187.20924, 31.698789, -21.509372
1182, -185.36421, 30.518365, 19.481482
1183, -197.06615, 26.591253, 41.73461
1184, -258.93982, 31.091474, 61.399931
1185, -272.0383, 19.15833, -41.497618
1186, -105.82396, 34.131385, 139.3414
1187, -107.97698, 26.763562, 101.54809
1188, -139.96299, 29.816095, 72.199741
1189, -87.679841, 28.346921, 166.54812
1190, -230.52742, 30.485965, 143.4749
1191, -64.778196, 30.592537, 241.24628
1192, -19.088458, 30.333719, 170.95924
1193, -35.169682, 38.854037, 191.59322
1194, 39.95883, 28.278438, 214.39127
1195, -1.996363, 28.326888, 155.79503
1196, -44.52531, 20.356086, 225.68658
1197, 35.278676, 29.394015, 196.13774
1198, 19.137941, 32.003824, 169.26229
1199, 59.642953, 29.990898, 237.46809
1200, 39.091403, 29.190522, 238.43313
1201, 64.034527, 32.921888, 262.94534
1202, 0.93563905, 29.98468, 275.44925
1203, -50.431583, 30.875433, 268.00111
1204, 1187.877, 29.877941, -90.002774
1205, -56.995782, 36.302205, 209.93905
1206, 39.729477, 37.349541, -228.55988
1207, 55.397835, 28.656919, -223.78471
1208, 76.224374, 26.470576, -225.91404
1209, 107.13851, 31.331945, -230.18415
1210, 39.920871, 36.398877, -213.66478
1211, 41.55989, 44.876278, -200.49296
1212, 72.361295, 29.750809, -163.6731
1213, 37.566222, 16.878679, -207.85211
1214, 1.4384495, 45.142488, -182.44883
1215, 20.510071, 42.608555, -188.41522
1216, 23.361468, 16.938711, -186.94101
1217, 8.7329905, 26.65295, -186.79129
1218, -0.38962162, 13.672907, -180.15924
1219, -17.718378, 44.754234, -188.37448
1220, -52.100465, 26.717904, -180.39873
1221, -7.1933209, 30.428097, -185.35524
1222, -62.845099, 30.356639, -202.4153
1223, -92.630528, 29.672276, -178.79498
1224, -59.569167, 25.439201, -155.99438
1225, -21.643475, 18.436422, -186.82084
1226, -37.993957, 44.291614, -206.23825
1227, -63.933269, 31.85166, -226.66646
1228, -38.875402, 17.777883, -203.29818
1229, -40.047431, 28.201103, -217.47368
1230, -44.474918, 13.489698, -222.32103
1231, -42.032105, 44.23201, -235.28808
1232, -41.655823, 28.414227, -234.38228
1233, -41.492393, 14.899171, -245.10055
1234, -35.946764, 29.612478, -251.29464
1235, -24.951189, 41.461211, -268.83411
1236, -5.0318955, 41.483246, -270.41925
1237, -36.121376, 45.59026, -251.74987
1238, -6.5601179, 18.067101, -271.79183
1239, 13.723262, 42.685975, -272.15118
1240, 13.434871, 19.350317, -272.28003
1241, -27.063915, 16.623385, -268.07748
1242, 36.574991, 31.555253, -248.44299
1243, 41.413103, 46.471514, -243.10538
1244, 40.050657, 15.34077, -251.38045
1245, 40.427058, 27.29202, -236.50747
1246, 42.901664, 12.913494, -233.96011
1247, -124.32671, 29.417257, -197.57995
1248, -121.88582, 36.651301, -178.15471
1249, -111.87999, 43.83736, -165.30163
1250, -118.177, 36.107465, -142.90071
1251, -86.488063, 34.70637, -137.14458
1252, -132.58658, 28.12614, -94.222248
1253, -152.17366, 40.939523, -115.97269
1254, -149.63646, 18.9565, -117.21375
1255, -168.76289, 17.818473, -115.63727
1256, -188.46706, 44.920693, -126.91209
1257, -186.77016, 23.609257, -121.01568
1258, -201.08127, 38.801521, -136.30043
1259, -232.51356, 30.337759, -106.47156
1260, -202.01809, 20.83789, -90.673556
1261, -203.02943, 18.644334, -136.49958
1262, -207.7312, 39.293013, -155.70665
1263, -205.68199, 36.094495, -181.67733
1264, -209.07351, 18.851901, -161.53162
1265, -161.83816, 44.003881, -204.58747
1266, -161.03316, 35.253373, -227.47103
1267, -174.55687, 16.54106, -209.48695
1268, -154.75403, 21.070408, -206.08991
1269, -224.69166, 27.855263, -67.292825
1270, -237.05422, 28.271439, -40.57816
1271, -227.85089, 44.014527, -42.561003
1272, -210.49299, 14.175003, -43.296982
1273, -208.7836, 45.396324, -40.636573
1274, -171.70866, 34.734734, -48.849885
1275, -197.17824, 30.820071, -63.495046
1276, -160.06924, 23.621098, -26.083208
1277, -146.5949, 27.66842, 22.953487
1278, -223.19525, 29.314764, 51.081562
1279, -237.9628, 28.805858, 87.394373
1280, -240.11052, 40.319764, 42.912942
1281, -244.23111, 18.131691, 42.793574
1282, -276.42265, 35.592948, 11.244652
1283, -273.83016, 13.580151, 1.374957
1284, -267.84047, 25.458002, -5.8089838
1285, -272.35905, 42.678174, -5.5326289
1286, -260.09848, 39.549402, 33.167338
1287, -266.31206, 18.306674, 28.282162
1288, -267.28766, 36.428129, -26.246267
1289, -282.97042, 19.062894, -14.164742
1290, -266.08928, 15.120086, -19.422369
1291, -251.03061, 41.436567, -41.135865
1292, -251.51728, 17.042969, -37.775622
1293, -232.63802, 13.289641, -44.905804
1294, -160.38463, 29.422925, 97.174275
1295, -202.18142, 30.432694, 134.59834
1296, -196.9121, 30.744175, 101.07635
1297, -185.83923, 39.584465, 125.16688
1298, -179.42702, 44.257398, 109.13402
1299, -190.09729, 26.369974, 74.317082
1300, -221.73872, 30.691372, 112.70762
1301, -184.11379, 21.125773, 120.46651
1302, -168.07045, 41.224405, 120.0532
1303, -164.43417, 21.296633, 116.78561
1304, -146.07271, 18.816109, 117.94025
1305, -142.48717, 41.826862, 120.99547
1306, -133.49886, 44.655413, 101.20002
1307, -119.02421, 15.130321, 143.2727
1308, -73.822257, 28.466435, 128.87337
1309, -126.50725, 24.279039, 128.9097
1310, -113.66111, 42.878087, 165.62204
1311, -115.1928, 23.943666, 159.38933
1312, -120.08062, 44.745684, 152.21672
1313, -119.53734, 31.669131, 185.32802
1314, -89.418644, 31.843616, 196.53729
1315, -117.09537, 27.508942, 221.28742
1316, -142.54089, 28.867517, 209.09116
1317, -136.15799, 45.416511, 194.88037
1318, -166.09783, 33.444112, 206.17338
1319, -204.61747, 40.834438, 181.40759
1320, -206.53609, 41.771949, 156.51874
1321, -202.34023, 18.72599, 185.44011
1322, -208.86939, 19.523618, 159.69236
1323, -38.138152, 31.384638, 212.86951
1324, -83.690283, 30.531376, 221.70613
1325, -41.854387, 35.777197, 228.85177
1326, -39.107443, 44.972016, 219.01802
1327, -46.149451, 48.951619, 230.03661
1328, -49.222244, 29.227963, 172.52334
1329, -38.786131, 17.110967, 205.0381
1330, -36.139022, 46.259528, 205.82806
1331, 1.3373622, 42.126854, 184.34504
1332, -18.264759, 44.353148, 188.42889
1333, -24.391899, 29.910597, 128.65111
1334, -22.823022, 18.442535, 190.331
1335, 0.39272321, 17.659596, 183.50631
1336, 54.590301, 28.563374, 172.36012
1337, 63.780967, 27.082862, 209.89005
1338, 26.931208, 29.060853, 136.26302
1339, 19.668139, 45.017978, 190.7394
1340, 17.863437, 15.040787, 190.33047
1341, 45.196951, 44.729605, 213.33163
1342, 41.2657, 12.906691, 212.0918
1343, 41.533916, 34.73729, 226.93503
1344, 44.895637, 20.200742, 226.52869
1345, 44.864295, 46.832199, 238.90048
1346, 37.4332, 38.672289, 253.13966
1347, 41.614431, 16.924052, 249.15026
1348, 25.255788, 29.294292, 267.65212
1349, -34.273295, 40.639231, 257.7088
1350, -22.710205, 30.31056, 273.81874
1351, -42.118685, 27.765003, 244.08704
1352, -45.220083, 45.920347, 246.43516
1353, -35.28926, 19.134051, 256.24971
1354, 1130.6562, 30.041804, -84.744391
1355, 1046.5374, 29.930911, 1.5342641
1356, 1055.1634, 29.998736, -33.83515
1357, 1060.9352, 30.739043, 35.881822
1358, 1127.9122, 29.982865, 86.64734
1359, 1174.6935, 30.015754, 85.302491
1360, 1172.8132, 30.043909, 118.16158
1361, 1222.4848, 29.902682, 89.961597
1362, 1290.8161, 31.642965, -15.152491
1363, 1287.7617, 28.962596, 25.353849
1364, 55.728444, 0, -294.77846
1365, 21.102071, 0, -299.25692
1366, -9.4466332, 0, -299.85123
1367, -38.273751, 0, -297.54852
1368, -74.17315, 0, -290.68599
1369, -116.05544, 0, -276.64261
1370, -152.14073, 0, -258.55986
1371, -180.71584, 0, -239.46145
1372, -205.33258, 0, -218.72021
1373, -227.58531, 0, -195.46081
1374, -247.52662, 0, -169.50095
1375, -267.05189, 0, -136.68682
1376, -284.2289, 0, -95.98924
1377, -294.74707, 0, -55.894212
1378, -299.245, 0, -21.270363
1379, -299.82075, 0, 10.36912
1380, -296.50287, 0, 45.673255
1381, -286.58156, 0, 88.718694
1382, -267.79402, 0, 135.22708
1383, -246.28644, 0, 171.29795
1384, -227.94057, 0, 195.04639
1385, -207.31387, 0, 216.84316
1386, -181.58604, 0, 238.80224
1387, -147.88646, 0, 261.01647
1388, -101.30345, 0, 282.37849
1389, -52.839264, 0, 295.31003
1390, -15.445734, 0, 299.60212
1391, 16.198962, 0, 299.56234
1392, 53.044419, 0, 295.27325
1393, 97.573147, 0, 284.81081
1394, 152.31912, 0, 271.5755
1395, 229.45077, 0, 254.13217
1396, 334.78838, 0, 232.55814
1397, 446.77596, 0, 212.43105
1398, 545.14964, 0, 197.1091
1399, 634.23472, 0, 185.11733
1400, 725.80158, 0, 174.64168
1401, 811.89186, 0, 166.49179
1402, 884.49774, 0, 160.89184
1403, 957.18355, 0, 156.44824
1404, 1033.9107, 0, 153.01582
1405, 1103.2901, 0, 151.02228
1406, 1167.0027, 0, 150.119
1407, 1233.8702, 0, 146.12601
1408, 1296.6986, 0, 114.67073
1409, 1337.3809, 0, 60.220242
1410, 1349.9882, 0, 1.884906
1411, 1338.8509, 0, -56.748828
1412, 1297.7751, 0, -113.75429
1413, 1233.411, 0, -146.23169
1414, 1164.7271, 0, -150.13598
1415, 1097.0334, 0, -151.15885
1416, 1027.0883, 0, -153.26876
1417, 954.34299, 0, -156.6001
1418, 889.03845, 0, -160.58022
1419, 822.66352, 0, -165.58752
1420, 736.55423, 0, -173.53397
1421, 639.31609, 0, -184.48697
1422, 544.58658, 0, -197.19057
1423, 450.14313, 0, -211.8703
1424, 345.40528, 0, -230.52641
1425, 239.46074, 0, -251.9709
1426, 157.30403, 0, -270.40573
1427, 98.6775, 0, -284.53676
1428, 92.715857, 0, 24.895178
1429, 67.775538, 0, 67.988796
1430, 24.60378, 0, 92.79361
1431, -25.040785, 0, 92.676637
1432, -67.988796, 0, 67.775538
1433, -92.754848, 0, 24.749509
1434, -92.715857, 0, -24.895178
1435, -67.882251, 0, -67.882251
1436, -25.040785, 0, -92.676637
1437, 24.60378, 0, -92.79361
1438, 67.882251, 0, -67.882251
1439, 92.754848, 0, -24.749509
1440, 685.89482, 0, 31.118972
1441, 654.85281, 0, 84.852814
1442, 601.11897, 0, 115.89482
1443, 539.06311, 0, 115.94356
1444, 485.14719, 0, 84.852814
1445, 454.05644, 0, 30.936887
1446, 454.10518, 0, -31.118972
1447, 485.28058, 0, -84.985995
1448, 539.24528, 0, -115.99201
1449, 601.30098, 0, -115.8458
1450, 654.986, 0, -84.719423
1451, 685.94356, 0, -30.936887
1452, 986.92112, 0, 23.339229
1453, 963.53957, 0, 63.739497
1454, 923.06604, 0, 86.994009
1455, 876.52426, 0, 86.884347
1456, 836.2605, 0, 63.539567
1457, 813.04233, 0, 23.202665
1458, 813.04233, 0, -23.202665
1459, 836.0612, 0, -63.33901
1460, 875.97882, 0, -86.735131
1461, 923.33923, 0, -86.921116
1462, 964.13747, 0, -63.137828
1463, 986.99401, 0, -23.066044
1464, 28.998003, 0, -220.31132
1465, 21.412188, 0, -206.98767
1466, 8.0524642, 0, -199.1009
1467, -7.9161915, 0, -199.06328
1468, -21.478094, 0, -207.05504
1469, -29.010045, 0, -220.35688
1470, -28.973705, 0, -235.77974
1471, -21.179856, 0, -249.2465
1472, -7.6886812, 0, -256.998
1473, 7.8252452, 0, -256.96145
1474, 21.246499, 0, -249.17986
1475, 28.98589, 0, -235.73422
1476, -135.23173, 0, -176.20674
1477, -131.22035, 0, -161.22035
1478, -135.20823, 0, -146.27479
1479, -146.11165, 0, -135.30264
1480, -161.03185, 0, -131.22094
1481, -176.12502, 0, -135.18478
1482, -187.30261, 0, -146.39754
1483, -191.21798, 0, -161.59733
1484, -187.04261, 0, -176.49159
1485, -176.04315, 0, -187.30261
1486, -161.1261, 0, -191.2202
1487, -146.19315, 0, -187.18539
1488, -220.22026, 0, -28.973705
1489, -206.7868, 0, -21.213203
1490, -199.02629, 0, -7.779743
1491, -199.01411, 0, 7.7342216
1492, -206.72026, 0, 21.146456
1493, -220.17475, 0, 28.961449
1494, -235.77974, 0, 28.973705
1495, -249.27974, 0, 21.146456
1496, -257.01004, 0, 7.6431218
1497, -256.94912, 0, -7.8707281
1498, -249.14646, 0, -21.279742
1499, -235.73422, 0, -28.98589
1500, -176.20674, 0, 135.23173
1501, -161.22035, 0, 131.22035
1502, -146.19315, 0, 135.25531
1503, -135.20823, 0, 146.27479
1504, -131.22038, 0, 161.26747
1505, -135.25531, 0, 176.24754
1506, -146.23395, 0, 187.20896
1507, -161.26747, 0, 191.22031
1508, -176.24754, 0, 187.18539
1509, -187.20896, 0, 176.20674
1510, -191.22031, 0, 161.17322
1511, -187.18539, 0, 146.19315
1512, -28.973705, 0, 220.22026
1513, -21.179856, 0, 206.7535
1514, -7.6886812, 0, 199.002
1515, 7.8252452, 0, 199.03855
1516, 21.246499, 0, 206.82014
1517, 28.98589, 0, 220.26578
1518, 28.98589, 0, 235.73422
1519, 21.179856, 0, 249.2465
1520, 7.6431218, 0, 257.01004
1521, -7.8252452, 0, 256.96145
1522, -21.279742, 0, 249.14646
1523, -28.998003, 0, 235.68868
1524, 1184.76, 0, -60
1525, 1154.76, 0, -60
1526, 1215.4684, 0, 57.97178
1527, 1242.2929, 0, 42.559484
1528, 1257.8982, 0, 15.741456
1529, 1258.0201, 0, -15.286244
1530, 1242.6921, 0, -42.158998
1531, 1215.7415, 0, -57.898243
1532, 1156.68, 0, 60
1533, 1186.68, 0, 60
1534, 1124.4405, 0, -57.947411
1535, 1097.5736, 0, -42.426407
1536, 1082.0526, 0, -15.559486
1537, 1082.0282, 0, 15.468443
1538, 1097.5736, 0, 42.426407
1539, 1124.5316, 0, 57.97178
1540, 73.846154, 14.22, 290.76923
1541, 73.846154, 44.22, 290.76923
1542, 55.728444, 60, -294.77846
1543, 21.646536, 60, -299.21803
1544, -8.9010367, 60, -299.86792
1545, -37.732296, 60, -297.61766
1546, -72.585338, 60, -291.08653
1547, -113.5339, 60, -277.68697
1548, -150.72711, 60, -259.38646
1549, -180.27984, 60, -239.78987
1550, -204.93428, 60, -219.09345
1551, -227.22929, 60, -195.87458
1552, -247.52662, 60, -169.50095
1553, -267.54753, 60, -135.71411
1554, -284.40308, 60, -95.471925
1555, -294.94852, 60, -54.821256
1556, -299.39188, 60, -19.091906
1557, -299.75968, 60, 12.005535
1558, -295.9866, 60, 48.907402
1559, -284.91998, 60, 93.918091
1560, -265.79735, 60, 139.11064
1561, -244.40174, 60, 173.97641
1562, -225.7977, 60, 197.52316
1563, -205.33258, 60, 218.72021
1564, -179.84324, 60, 240.11749
1565, -145.98287, 60, 262.08587
1566, -99.760578, 60, 282.92725
1567, -51.764279, 60, 295.50035
1568, -14.900581, 60, 299.62973
1569, 16.198962, 60, 299.56234
1570, 53.044419, 60, 295.27325
1571, 73.846154, 30, -290.76923
1572, 1200, 30, -150
1573, 1165.8649, 60, -150.12735
1574, 1101.0149, 60, -151.07095
1575, 1033.9107, 60, -153.01582
1576, 962.86496, 60, -156.14982
1577, 899.82387, 60, -159.85824
1578, 839.67568, 60, -164.21154
1579, 752.40494, 60, -171.94787
1580, 648.35136, 60, -183.38038
1581, 551.34398, 60, -196.21756
1582, 449.02069, 60, -212.05694
1583, 335.34704, 60, -232.45058
1584, 229.45077, 60, -254.13217
1585, 152.31912, 60, -271.5755
1586, 97.573147, 60, -284.81081
1587, 1233.8702, 60, 146.12601
1588, 1295.9762, 60, 115.27604
1589, 1337.9424, 60, 58.922802
1590, 1349.8651, 60, -6.3598181
1591, 1333.7578, 60, -67.888553
1592, 1292.1221, 60, -118.37869
1593, 1232.4915, 60, -146.43873
1594, 1200, 30, 150
1595, 99.229703, 60, 284.39984
1596, 158.96595, 60, 270.01705
1597, 244.46753, 60, 250.89867
1598, 358.26369, 60, 228.10051
1599, 474.28663, 60, 207.92516
1600, 575.00614, 60, 192.89148
1601, 671.51413, 60, 180.62681
1602, 767.6947, 60, 170.4707
1603, 851.01992, 60, 163.32948
1604, 923.67118, 60, 158.35272
1605, 1007.7603, 60, 154.0407
1606, 1093.052, 60, 151.25021
1607, 1165.296, 60, 150.13163
1608, 145.63259, 60, -35.932544
1609, 114.21378, 60, -97.237921
1610, 71.021011, 60, -132.12122
1611, 33.181214, 60, -146.28399
1612, 0.47123812, 60, -149.99926
1613, -32.261436, 60, -146.48959
1614, -67.678363, 60, -133.86426
1615, -99.19678, 60, -112.51666
1616, -124.06209, 60, -84.312507
1617, -141.68227, 60, -49.255819
1618, -149.24265, 60, -15.054257
1619, -149.17005, 60, 15.757377
1620, -140.64697, 60, 52.138551
1621, -122.99282, 60, 85.864819
1622, -101.64697, 60, 110.30818
1623, -75.135994, 60, 129.8252
1624, -41.848666, 60, 144.04405
1625, -7.7719602, 60, 149.79852
1626, 23.93049, 60, 148.0788
1627, 63.65362, 60, 135.82421
1628, 110.46771, 60, 101.47357
1629, 144.92945, 60, 38.671108
1630, 685.89482, 60, 31.118972
1631, 654.85281, 60, 84.852814
1632, 601.11897, 60, 115.89482
1633, 539.06311, 60, 115.94356
1634, 485.14719, 60, 84.852814
1635, 454.05644, 60, 30.936887
1636, 454.10518, 60, -31.118972
1637, 485.28058, 60, -84.985995
1638, 539.24528, 60, -115.99201
1639, 601.30098, 60, -115.8458
1640, 654.986, 60, -84.719423
1641, 685.94356, 60, -30.936887
1642, 986.92112, 60, 23.339229
1643, 963.53957, 60, 63.739497
1644, 923.06604, 60, 86.994009
1645, 876.52426, 60, 86.884347
1646, 836.2605, 60, 63.539567
1647, 813.04233, 60, 23.202665
1648, 813.04233, 60, -23.202665
1649, 836.0612, 60, -63.33901
1650, 875.97882, 60, -86.735131
1651, 923.33923, 60, -86.921116
1652, 964.13747, 60, -63.137828
1653, 986.99401, 60, -23.066044
1654, 28.98589, 60, -220.26578
1655, 21.279742, 60, -206.85354
1656, 7.6886812, 60, -199.002
1657, -8.0070597, 60, -199.08829
1658, -21.34607, 60, -206.9205
1659, -28.998003, 60, -220.31132
1660, -28.973705, 60, -235.77974
1661, -21.179856, 60, -249.2465
1662, -7.7342216, 60, -256.98589
1663, 7.779743, 60, -256.97371
1664, 21.246499, 60, -249.17986
1665, 28.98589, 60, -235.73422
1666, -135.23173, 60, -176.20674
1667, -131.22038, 60, -161.17322
1668, -135.27894, 60, -146.15238
1669, -146.27479, 60, -135.20823
1670, -161.26747, 60, -131.22038
1671, -176.24754, 60, -135.25531
1672, -187.20896, 60, -146.23395
1673, -191.22031, 60, -161.26747
1674, -187.18539, 60, -176.24754
1675, -176.20674, 60, -187.20896
1676, -161.17322, 60, -191.22031
1677, -146.19315, 60, -187.18539
1678, -220.22026, 60, -28.973705
1679, -206.7535, 60, -21.179856
1680, -199.002, 60, -7.6886812
1681, -199.03855, 60, 7.8252452
1682, -206.82014, 60, 21.246499
1683, -220.26578, 60, 28.98589
1684, -235.77974, 60, 28.973705
1685, -249.2465, 60, 21.179856
1686, -256.98589, 60, 7.7342216
1687, -256.97371, 60, -7.779743
1688, -249.17986, 60, -21.246499
1689, -235.73422, 60, -28.98589
1690, -176.20674, 60, 135.23173
1691, -161.17322, 60, 131.22038
1692, -146.19315, 60, 135.25531
1693, -135.23173, 60, 146.23395
1694, -131.22038, 60, 161.26747
1695, -135.25531, 60, 176.24754
1696, -146.23395, 60, 187.20896
1697, -161.26747, 60, 191.22031
1698, -176.24754, 60, 187.18539
1699, -187.20896, 60, 176.20674
1700, -191.22031, 60, 161.17322
1701, -187.18539, 60, 146.19315
1702, -28.973705, 60, 220.22026
1703, -21.179856, 60, 206.7535
1704, -7.6886812, 60, 199.002
1705, 7.8252452, 60, 199.03855
1706, 21.246499, 60, 206.82014
1707, 28.98589, 60, 220.26578
1708, 28.973705, 60, 235.77974
1709, 21.146456, 60, 249.27974
1710, 7.5975435, 60, 257.02201
1711, -7.9161915, 60, 256.93672
1712, -21.279742, 60, 249.14646
1713, -28.98589, 60, 235.73422
1714, 1184.76, 60, -60
1715, 1154.76, 60, -60
1716, 1124.4405, 60, -57.947411
1717, 1097.5736, 60, -42.426407
1718, 1082.0526, 60, -15.559486
1719, 1082.0282, 60, 15.468443
1720, 1097.5736, 60, 42.426407
1721, 1124.5316, 60, 57.97178
1722, 1155.99, 60, 60
1723, 1185.99, 60, 60
1724, 1215.4684, 60, 57.97178
1725, 1242.2929, 60, 42.559484
1726, 1257.8982, 60, 15.741456
1727, 1258.0201, 60, -15.286244
1728, 1242.6921, 60, -42.158998
1729, 1215.7415, 60, -57.898243
1730, 20, 330, -148.66069
1731, 145.49371, 360, -36.490843
1732, 111.41316, 360, -100.43459
1733, 53.455578, 360, -140.15171
1734, 150, 116.1, 1.8369702e-14
1735, 150, 223.2, 1.8369702e-14
1736, 150, 317.1, 1.8369702e-14
1737, -150, 76.05, -1.8369702e-14
1738, -150, 117.15, -1.8369702e-14
1739, -150, 177.3, -1.8369702e-14
1740, -150, 255.6, -1.8369702e-14
1741, -150, 329.4, -1.8369702e-14
1742, -56.464031, 360, -138.96695
1743, -116.25364, 360, -94.789719
1744, -146.45902, 360, -32.399915
1745, -20, 330, -148.66069
1746, -3.5527137e-15, 300, -150
1747, 20, 300, -121.27712
1748, 3.5527137e-15, 300, -96
1749, -20, 300, -121.27712
1750, 3.5527137e-15, 300, 150
1751, -20, 300, 121.27712
1752, -3.5527137e-15, 300, 96
1753, 20, 300, 121.27712
1754, 20, 360, 121.27712
1755, 20, 330, 148.66069
1756, 20, 330, 93.893557
1757, 20, 360, -121.27712
1758, 20, 330, -93.893557
1759, -20, 360, -121.27712
1760, -93.531274, 360, -21.631013
1761, -74.577916, 360, -60.449437
1762, -40.582874, 360, -87.000175
1763, -40.642065, 360, 86.972539
1764, -74.660114, 360, 60.347886
1765, -93.545972, 360, 21.567363
1766, -20, 360, 121.27712
1767, -147.5671, 360, 26.906326
1768, -129.01684, 360, 76.515718
1769, -94.045837, 360, 116.85624
1770, -46.3417, 360, 142.662
1771, 93.531274, 360, 21.631013
1772, 74.577916, 360, 60.449437
1773, 40.582874, 360, 87.000175
1774, 40.819524, 360, -86.889392
1775, 74.865004, 360, -60.09352
1776, 93.575237, 360, -21.440034
1777, 53.757564, 360, 140.03615
1778, 111.77327, 360, 100.03367
1779, 145.546, 360, 36.281722
1780, -20, 330, -93.893557
1781, -20, 330, 93.893557
1782, -20, 330, 148.66069
1783, 96, 334.44, -2.094146e-14
1784, 96, 266.58, -2.094146e-14
1785, 96, 176.76, -2.094146e-14
1786, 96, 91.44, -2.094146e-14
1787, 96, 26.82, -2.094146e-14
1788, -96, 331.92, 0
1789, -96, 265.14, 0
1790, -96, 176.94, 0
1791, -96, 94.14, 0
1792, -96, 30.42, 0
1793, 690, 30, -1.4695762e-14
1794, 450, 30, 1.4695762e-14
1795, 990, 30, -1.1021821e-14
1796, 810, 30, 1.1021821e-14
1797, 30, 52.47, -228
1798, 30, 37.44, -228
1799, 30, 22.47, -228
1800, 30, 7.5, -228
1801, -30, 52.47, -228
1802, -30, 37.44, -228
1803, -30, 22.47, -228
1804, -30, 7.5, -228
1805, -140.00714, 52.47, -182.43355
1806, -140.00714, 37.44, -182.43355
1807, -140.00714, 22.47, -182.43355
1808, -140.00714, 7.5, -182.43355
1809, -182.43355, 52.47, -140.00714
1810, -182.43355, 37.44, -140.00714
1811, -182.43355, 22.47, -140.00714
1812, -182.43355, 7.5, -140.00714
1813, -228, 52.47, -30
1814, -228, 37.44, -30
1815, -228, 22.47, -30
1816, -228, 7.5, -30
1817, -228, 52.47, 30
1818, -228, 37.44, 30
1819, -228, 22.47, 30
1820, -228, 7.5, 30
1821, -182.43355, 52.47, 140.00714
1822, -182.43355, 37.44, 140.00714
1823, -182.43355, 22.47, 140.00714
1824, -182.43355, 7.5, 140.00714
1825, -140.00714, 52.47, 182.43355
1826, -140.00714, 37.44, 182.43355
1827, -140.00714, 22.47, 182.43355
1828, -140.00714, 7.5, 182.43355
1829, -30, 52.47, 228
1830, -30, 37.44, 228
1831, -30, 22.47, 228
1832, -30, 7.5, 228
1833, 30, 52.47, 228
1834, 30, 37.44, 228
1835, 30, 22.47, 228
1836, 30, 7.5, 228
1837, 1140, 44.97, -60
1838, 1140, 14.97, -60
1839, 1200, 44.97, -60
1840, 1200, 14.97, -60
1841, 1140, 44.97, 60
1842, 1140, 14.97, 60
1843, 1200, 44.97, 60
1844, 1200, 14.97, 60
1845, 32.135206, 0, -288.41233
1846, 15.808321, 0, -289.56362
1847, -32.176628, 0, -287.77142
1848, -46.788317, 0, -285.89191
1849, -62.878811, 0, -278.2996
1850, -84.016338, 0, -272.90603
1851, -56.827864, 0, -268.88149
1852, -106.24684, 0, -265.12725
1853, -126.86517, 0, -256.47757
1854, -95.148856, 0, -253.5104
1855, -142.38074, 0, -247.34796
1856, -169.08187, 0, -235.72326
1857, -182.14643, 0, -225.86375
1858, -217.01122, 0, -192.63543
1859, -227.67519, 0, -180.21881
1860, -231.52601, 0, -166.74796
1861, -240.77366, 0, -153.24338
1862, -221.29089, 0, -164.2137
1863, -247.83861, 0, -138.65907
1864, -257.77794, 0, -119.24012
1865, -232.20667, 0, -136.15854
1866, -280.86306, 0, -66.859099
1867, -284.42015, 0, -48.101488
1868, -283.19463, 0, 36.650805
1869, -280.20507, 0, 56.058518
1870, -273.69557, 0, 72.184115
1871, -266.43959, 0, 95.62257
1872, -261.02318, 0, 63.259611
1873, -240.65088, 0, 156.89355
1874, -231.30519, 0, 170.33047
1875, -179.39019, 0, 225.89414
1876, -165.49397, 0, 236.46087
1877, -150.62523, 0, 243.38829
1878, -130.69795, 0, 254.67867
1879, -148.73708, 0, 230.88486
1880, 84.276434, 0, 267.53402
1881, 108.01919, 0, 261.63908
1882, 135.19801, 0, 242.91569
1883, 166.21087, 0, 235.61982
1884, 121.88553, 0, 225.57541
1885, 304.77513, 0, 190.81788
1886, 363.99112, 0, 179.41331
1887, 534.78765, 0, 161.96742
1888, 580.39521, 0, 155.37138
1889, 623.86544, 0, 149.95407
1890, 696.57951, 0, 143.5642
1891, 744.67669, 0, 138.55193
1892, 814.42183, 0, 123.88937
1893, 852.4019, 0, 120.65577
1894, 887.02332, 0, 118.2625
1895, 931.98245, 0, 118.33312
1896, 970.04619, 0, 116.31005
1897, 1255.2604, 44.999531, 23.372862
1898, 1251.1233, 29.996648, 31.407076
1899, 1246.7093, 44.997117, 37.659592
1900, 1326.993, 0, 13.561796
1901, 1327.3462, 0, -14.543181
1902, 1115.39, 0, -122.32042
1903, 1082.9698, 0, -123.05026
1904, 1042.3583, 0, -119.45329
1905, 1004.8366, 0, -120.87243
1906, 1060.7123, 0, -90.499959
1907, 967.69304, 0, -116.15433
1908, 932.47098, 0, -118.04833
1909, 886.77905, 0, -118.12011
1910, 856.69602, 0, -120.16958
1911, 820.40932, 0, -123.17266
1912, 768.80635, 0, -138.72476
1913, 718.99957, 0, -143.79626
1914, 658.44199, 0, -141.36908
1915, 611.01348, 0, -147.22577
1916, 465.94819, 0, -165.02611
1917, 418.80571, 0, -172.85884
1918, 365.81235, 0, -177.36807
1919, 308.24617, 0, -188.3139
1920, 381.5765, 0, -130.27766
1921, 254.97428, 0, -209.4667
1922, 206.58204, 0, -219.85846
1923, 275.31125, 0, -155.93968
1924, 170.41457, 0, -231.596
1925, 136.62388, 0, -239.50546
1926, 185.87189, 0, -188.83002
1927, 103.31025, 0, -267.34931
1928, 78.461662, 0, -273.51225
1929, 116.60802, 0, 18.916593
1930, 110.15208, 0, 42.960111
1931, 90.834301, 0, 74.424036
1932, 73.203123, 0, 91.999912
1933, 43.139284, 0, 103.69339
1934, 19.075602, 0, 110.07376
1935, -18.951754, 0, 108.9395
1936, -42.844476, 0, 102.4838
1937, -71.763377, 0, 85.669853
1938, -89.339253, 0, 68.038674
1939, -108.3268, 0, 34.94852
1940, -114.70741, 0, 11.035635
1941, -114.40431, 0, -13.152135
1942, -107.94838, 0, -37.195653
1943, -85.225831, 0, -68.155924
1944, -67.725285, 0, -85.65647
1945, -35.579318, 0, -107.74193
1946, -11.686596, 0, -114.19763
1947, 21.040354, 0, -115.57307
1948, 45.104035, 0, -109.1927
1949, 72.452139, 0, -90.816767
1950, 90.158648, 0, -73.110259
1951, 109.54364, 0, -43.676069
1952, 115.92425, 0, -19.763184
1953, 504.89654, 0, 153.99166
1954, 471.97919, 0, 116.21458
1955, 449.84606, 0, 94.081444
1956, 434.32695, 0, 56.932603
1957, 426.35119, 0, 27.041497
1958, 419.86989, 0, -20.327184
1959, 427.93981, 0, -50.381582
1960, 450.35485, 0, -92.938608
1961, 472.39382, 0, -114.90845
1962, 581.14758, 0, -155.2954
1963, 719.3216, 0, -55.292666
1964, 727.29736, 0, -25.40156
1965, 1005.5386, 0, 16.726074
1966, 999.48618, 0, 39.266872
1967, 787.22261, 0, 39.305013
1968, 781.24079, 0, 16.886683
1969, 787.29736, 0, -25.40156
1970, 793.27918, 0, -47.81989
1971, 982.95728, 0, -82.184882
1972, 999.13883, 0, -65.747131
1973, 1001.3497, 0, -34.478395
1974, 1007.2613, 0, -12.182755
1975, 36.440439, 0, -223.01291
1976, 34.469912, 0, -215.58103
1977, 29.129596, 0, -205.42442
1978, 23.776269, 0, -199.96922
1979, 14.475486, 0, -193.99044
1980, 6.8935881, 0, -191.87782
1981, -4.3981181, 0, -191.11267
1982, -12.208958, 0, -193.24947
1983, -24.368988, 0, -198.18874
1984, -29.705152, 0, -203.66073
1985, -34.580514, 0, -215.91077
1986, -36.527758, 0, -223.30168
1987, -35.040217, 0, -234.0652
1988, -33.022737, 0, -241.5788
1989, -27.689127, 0, -251.33868
1990, -22.179384, 0, -256.83114
1991, -12.494126, 0, -260.18659
1992, -4.9742261, 0, -262.18045
1993, 3.4468105, 0, -265.02468
1994, 10.913286, 0, -263.00728
1995, 22.640934, 0, -256.34992
1996, 28.133395, 0, -250.84018
1997, 33.737721, 0, -242.01394
1998, 35.73166, 0, -234.54117
1999, -132.33969, 0, -181.91452
2000, -128.45334, 0, -175.17503
2001, -123.72919, 0, -164.27081
2002, -123.72919, 0, -156.53658
2003, -127.90668, 0, -145.63263
2004, -131.75975, 0, -138.92652
2005, -139.7183, 0, -131.05324
2006, -146.40007, 0, -127.1581
2007, -157.65166, 0, -124.39504
2008, -165.38572, 0, -124.34645
2009, -176.90804, 0, -127.58524
2010, -183.73867, 0, -131.49559
2011, -191.75335, 0, -140.51238
2012, -195.68714, 0, -147.4343
2013, -197.43489, 0, -158.22225
2014, -197.3377, 0, -165.95586
2015, -194.64732, 0, -176.62613
2016, -190.71028, 0, -183.2833
2017, -182.91606, 0, -192.61189
2018, -176.23146, 0, -196.41082
2019, -164.8669, 0, -197.6442
2020, -157.13272, 0, -197.61991
2021, -145.80603, 0, -195.02514
2022, -139.11206, 0, -191.15102
2023, -222.36597, 0, -36.683284
2024, -214.85237, 0, -34.665803
2025, -204.72466, 0, -28.265675
2026, -199.25574, 0, -22.796754
2027, -193.17134, 0, -13.050016
2028, -191.15386, 0, -5.5364167
2029, -191.42025, 0, 5.4212982
2030, -193.41418, 0, 12.894075
2031, -199.32109, 0, 22.565968
2032, -204.77281, 0, 28.052043
2033, -216.01717, 0, 35.297844
2034, -223.57152, 0, 37.338993
2035, -234.65508, 0, 35.251877
2036, -242.16868, 0, 33.234397
2037, -249.88617, 0, 27.816662
2038, -255.40204, 0, 22.266022
2039, -263.86013, 0, 14.482018
2040, -265.83058, 0, 7.0030146
2041, -264.21223, 0, -6.1572986
2042, -262.17115, 0, -13.664523
2043, -255.60134, 0, -21.889042
2044, -250.11527, 0, -27.340755
2045, -241.72377, 0, -33.175778
2046, -234.25099, 0, -35.169718
2047, -182.84529, 0, 132.16411
2048, -176.1058, 0, 128.27777
2049, -163.86689, 0, 122.76053
2050, -156.13267, 0, 122.76053
2051, -144.49643, 0, 128.12963
2052, -137.72367, 0, 132.04935
2053, -130.69483, 0, 140.26246
2054, -126.84176, 0, 146.96858
2055, -123.76069, 0, 158.61694
2056, -123.77291, 0, 166.39667
2057, -129.03327, 0, 176.16758
2058, -132.90739, 0, 182.86156
2059, -140.0033, 0, 189.54287
2060, -146.74279, 0, 193.42921
2061, -156.08289, 0, 197.46881
2062, -163.86262, 0, 197.45659
2063, -176.13333, 0, 196.60169
2064, -182.82731, 0, 192.72757
2065, -190.97065, 0, 183.20314
2066, -194.85699, 0, 176.46365
2067, -197.5016, 0, 165.98689
2068, -197.48938, 0, 158.20716
2069, -196.3646, 0, 146.65966
2070, -192.49047, 0, 139.96568
2071, -35.756897, 0, 220.78099
2072, -33.739417, 0, 213.26739
2073, -27.272948, 0, 204.77205
2074, -21.763204, 0, 199.27959
2075, -12.418734, 0, 194.98149
2076, -4.8988332, 0, 192.98763
2077, 5.2006306, 0, 192.63257
2078, 12.667106, 0, 194.64998
2079, 22.256665, 0, 199.01862
2080, 27.749127, 0, 204.52837
2081, 34.215026, 0, 213.35315
2082, 36.208965, 0, 220.82593
2083, 37.29677, 0, 232.75156
2084, 35.302831, 0, 240.22434
2085, 30.172213, 0, 250.29781
2086, 24.598033, 0, 255.8545
2087, 14.85197, 0, 264.20731
2088, 7.3729657, 0, 266.17777
2089, -7.3750429, 0, 266.13066
2090, -14.841518, 0, 264.11325
2091, -24.475526, 0, 255.59103
2092, -29.991399, 0, 250.04039
2093, -35.015447, 0, 239.96249
2094, -36.985974, 0, 232.53061
2095, 1179.7166, 0, -76.35992
2096, 1194.9566, 0, -76.35992
2097, 1227.5114, 0, 71.821261
2098, 1212.5658, 0, 75.809139
2099, 1258.4696, 0, 49.291266
2100, 1247.4975, 0, 60.194691
2101, 1275.9628, 0, 18.137729
2102, 1271.8806, 0, 33.152177
2103, 1265.8612, 0, -28.299891
2104, 1269.8021, 0, -13.341883
2105, 1248.8188, 0, -59.328871
2106, 1259.6877, 0, -48.322521
2107, 1214.1868, 0, -75.537455
2108, 1229.3768, 0, -71.407564
2109, 1164.1352, 0, 80.742187
2110, 1147.4552, 0, 80.742187
2111, 1195.0012, 0, 75.644178
2112, 1181.6812, 0, 75.644178
2113, 1172.4564, 0, 96.386365
2114, 1207.567, 0, 91.453318
2115, 1105.6347, 0, -73.013507
2116, 1120.6619, 0, -77.048467
2117, 1077.7396, 0, -42.245067
2118, 1088.6774, 0, -53.182908
2119, 1070.9495, 0, -9.5923073
2120, 1074.9844, 0, -24.619506
2121, 1071.9931, 0, 22.821248
2122, 1068.0053, 0, 7.8756951
2123, 1088.9746, 0, 57.818806
2124, 1077.9081, 0, 46.752238
2125, 1125.9715, 0, 76.677448
2126, 1111.0259, 0, 72.689569
2127, 979.35397, 0, 83.617462
2128, 1004.5635, 0, 121.89115
2129, 1043.2244, 0, 120.48669
2130, 995.8832, 0, 67.140079
2131, 466.65795, 0, 166.15775
2132, 533.85176, 0, -162.1416
2133, -5.1448402, 0, -290.6295
2134, -19.324661, 0, -290.18277
2135, -188.55534, 0, -215.91827
2136, -200.09091, 0, -205.08878
2137, -266.69533, 0, -102.35275
2138, -273.84947, 0, -81.169002
2139, -287.00007, 0, -34.244271
2140, -288.1219, 0, -18.461731
2141, -286.80583, 0, 4.3210295
2142, -286.25895, 0, 20.133936
2143, -255.43394, 0, 114.67184
2144, -243.88384, 0, 137.54482
2145, -226.88453, 0, 181.50845
2146, -218.01539, 0, 191.87336
2147, -110.19005, 0, 257.79734
2148, -83.512844, 0, 267.3678
2149, -22.940725, 0, 286.31599
2150, -7.1393496, 0, 287.13062
2151, 7.608659, 0, 287.17772
2152, 23.407937, 0, 286.32337
2153, 251.21168, 0, 208.40899
2154, 280.33925, 0, 154.87387
2155, 205.06659, 0, 218.4263
2156, 413.91007, 0, 174.96227
2157, -221.61579, 0, 167.35919
2158, -243.50802, 0, 98.434477
2159, 1144.4588, 0, 125.98018
2160, 1177.4552, 0, 125.74219
2161, 1212.5658, 0, 120.80914
2162, 1245.5613, 0, 113.16121
2163, 1295.5271, 0, -75.809682
2164, 1266.2004, 0, -101.01682
2165, 1246.7584, 0, -113.09551
2166, 1214.1868, 0, -120.53745
2167, -248.18902, 0, -104.68686
2168, -273.71353, 0, -45.32246
2169, 802.8269, 0, -93.162424
2170, 758.53815, 0, -8.5148769
2171, 721.24079, 0, 16.886683
2172, -27.885403, 0, -278.88515
2173, 117.89826, 0, 69.297111
2174, 68.516636, 0, 112.45451
2175, -133.11172, 0, -2.1164999
2176, 9.6553502, 0, -133.77117
2177, 69.730404, 0, -116.77068
2178, 116.4635, 0, -68.960558
2179, 136.53227, 0, -0.84659141
2180, 713.17087, 0, 46.94108
2181, 694.64414, 0, 83.664522
2182, 672.76846, 0, 105.5402
2183, 503.77215, 0, -154.16614
2184, 396.22108, 0, 6.7143124
2185, 412.15481, 0, -83.211395
2186, 712.63621, 0, -84.248367
2187, 757.90933, 0, -79.75882
2188, 680.41184, 0, -119.3301
2189, 1017.4743, 0, 61.325355
2190, 820.60082, 0, 83.036839
2191, 804.12344, 0, 66.507609
2192, 1022.3117, 0, -55.634246
2193, 37.540563, 0, -207.8692
2194, 22.899465, 0, -191.73382
2195, 2.3069757, 0, -184.98989
2196, -21.14476, 0, -189.16401
2197, -38.180153, 0, -206.35332
2198, -41.567975, 0, -229.36688
2199, -34.746824, 0, -249.89028
2200, -19.727957, 0, -263.00561
2201, -1.6216632, 0, -269.20528
2202, 18.527022, 0, -265.39216
2203, 35.858995, 0, -249.90857
2204, 42.172099, 0, -229.55407
2205, -119.94807, 0, -170.49127
2206, -119.40141, 0, -148.68309
2207, -131.53745, 0, -129.90586
2208, -150.74758, 0, -119.26952
2209, -173.52147, 0, -119.74525
2210, -193.05847, 0, -132.00083
2211, -202.8209, 0, -151.80558
2212, -201.87826, 0, -173.2638
2213, -191.39366, 0, -193.26265
2214, -172.23489, 0, -203.82463
2215, -149.54365, 0, -202.46325
2216, -131.4446, 0, -190.63199
2217, -206.60422, 0, -36.966438
2218, -190.39211, 0, -20.819572
2219, -184.5741, 0, -0.11511846
2220, -190.7474, 0, 20.514489
2221, -207.89867, 0, 37.432184
2222, -230.2266, 0, 42.590871
2223, -249.02765, 0, 35.08602
2224, -265.20322, 0, 21.884281
2225, -272.04296, 0, 0.93996358
2226, -263.85479, 0, -20.444869
2227, -248.89349, 0, -34.504412
2228, -228.61696, 0, -41.853001
2229, -171.01812, 0, 118.80385
2230, -147.14297, 0, 118.65571
2231, -128.4779, 0, 132.23792
2232, -118.36799, 0, 152.09939
2233, -120.54728, 0, 173.51866
2234, -132.90355, 0, 189.97088
2235, -149.33955, 0, 200.69179
2236, -170.95036, 0, 203.87649
2237, -191.36441, 0, 193.49715
2238, -202.15235, 0, 173.49597
2239, -203.67218, 0, 151.47171
2240, -192.90221, 0, 132.12265
2241, -35.047325, 0, 205.06664
2242, -19.236385, 0, 192.2732
2243, 0.20754977, 0, 187.62005
2244, 19.896573, 0, 191.63364
2245, 35.952031, 0, 204.82708
2246, 43.505735, 0, 225.57749
2247, 39.462923, 0, 247.57659
2248, 24.586242, 0, 266.00287
2249, 0.092170457, 0, 274.30858
2250, -24.289846, 0, 265.73925
2251, -38.947901, 0, 247.13912
2252, -42.742871, 0, 225.3116
2253, 1209.1434, 0, -91.897375
2254, 1125.8491, 0, -97.008254
2255, 1145.1872, 0, -79.959786
2256, 1159.9472, 0, -79.959786
2257, 1245.1178, 0, 79.99171
2258, 1278.5149, 0, 52.226051
2259, 1293.3061, 0, -14.852583
2260, 1283.5037, 0, -1.3222045
2261, 1273.431, 0, -46.894892
2262, 1247.8156, 0, -78.996216
2263, 1133.4267, 0, 97.419635
2264, 1064.6541, 0, -36.810176
2265, 1084.3665, 0, -74.266336
2266, 1058.9547, 0, -1.7166122
2267, 1061.9254, 0, 39.68238
2268, 1089.8916, 0, 78.484133
2269, 1247.0394, 44.997159, -37.246445
2270, 1251.373, 29.996696, -30.99705
2271, 1255.4596, 44.999537, -22.896119
2272, 418.22149, 0, 91.231835
2273, 1022.7999, 0, 4.5433186
2274, 1170.1438, 0, -96.319707
2275, 1299.4668, 0, 16.627029
2276, -264.12001, 0, -73.48958
2277, -229.26941, 0, 136.83247
2278, 1194.9566, 0, -121.35992
2279, -177.19053, 0, -212.53673
2280, -131.95908, 0, -235.33656
2281, -156.96047, 0, -236.95291
2282, -78.888112, 0, -243.1026
2283, -101.11861, 0, -235.32382
2284, -158.66022, 0, -223.71186
2285, -238.11527, 0, 75.822692
2286, -227.10961, 0, 94.871961
2287, 1195.0012, 0, 120.64418
2288, 383.82165, 0, 132.83172
2289, -201.02836, 0, 204.11557
2290, -189.19781, 0, 215.42622
2291, -113.36044, 0, 240.93095
2292, 28.869008, 0, 275.3231
2293, 37.436765, 0, 287.29078
2294, 240.55443, 0, 123.10337
2295, 294.11788, 0, 105.51226
2296, 58.371995, 0, 283.52987
2297, -153.70458, 0, -214.99976
2298, -165.82598, 0, -213.77011
2299, -209.1717, 0, 194.59114
2300, -122.56976, 0, 226.97821
2301, -102.06186, 0, 230.09687
2302, 38.615071, 0, 266.97029
2303, -142.37789, 0, -212.405
2304, -173.41345, 0, 213.48951
2305, 1315.5038, 0, -64.433494
2306, 1287.2343, 0, -55.541334
2307, 653.91984, 0, 141.88415
2308, 48.011374, 0, 256.37908
2309, 52.294139, 0, 265.69931
2310, 53.141992, 0, 246.30561
2311, 1327.4478, 0, -35.209302
2312, 909.42274, 0, 124.31472
2313, 1122.975, 0, 121.91544
2314, 1307.1093, 0, -23.499025
2315, 1265.5474, 0, 101.53464
2316, 1293.3664, 0, 78.075627
2317, 1306.7774, 0, 61.936538
2318, 1319.4521, 0, 33.02173
2319, 909.14001, 0, -124.31294
2320, -228.73662, 0, -106.91687
2321, -237.65401, 0, -90.029496
2322, 1175.1872, 0, -124.95979
2323, 1139.9153, 0, -125.23174
2324, 122.72049, 0, -205.5979
2325, 109.63995, 0, -244.5358
2326, 283.60184, 0, -115.59096
2327, 230.32994, 0, -136.74375
2328, 192.78314, 0, -146.2979
2329, 156.61568, 0, -158.03544
2330, 201.07373, 0, -105.94918
2331, 89.406863, 0, -233.44176
2332, 17.856273, 0, 126.75241
2333, -1.5209214, 0, 112.67817
2334, -56.557408, 0, 120.95114
2335, -61.799968, 0, 101.55547
2336, -110.15148, 0, 76.244083
2337, -104.05101, 0, 56.031179
2338, -127.2086, 0, -49.116203
2339, -102.34835, 0, -60.007587
2340, -80.073801, 0, -106.95434
2341, -60.435553, 0, -104.386
2342, 367.89623, 0, 45.992918
2343, 361.41493, 0, -1.3757635
2344, -112.38293, 0, 93.465699
2345, -127.09469, 0, 81.458203
2346, 1293.4077, 0, -35.518703
2347, 368.30254, 0, 95.682876
2348, 1259.4877, 44.999537, -7.8242505
2349, 1259.9995, 29.999068, 0.23395431
2350, 1259.4311, 44.999531, 8.2428962
2351, 44.889877, 0, -281.46773
2352, 39.627557, 0, -272.22014
2353, 155.29537, 0, 73.414794
2354, 135.97759, 0, 104.87872
2355, 94.0128, 0, 219.48212
2356, 121.19162, 0, 200.75873
2357, 733.95486, 0, 70.496807
2358, -20.171083, 0, 125.61814
2359, -85.476309, 0, 104.1372
2360, -129.13902, 0, 43.153929
2361, -104.48605, 0, -80.076475
2362, -47.927834, 0, -129.0398
2363, 73.4533, 0, -144.1222
2364, 100.8014, 0, -125.74627
2365, 130.30272, 0, -106.94904
2366, 149.68771, 0, -77.514848
2367, 168.70001, 0, -23.764887
2368, 169.38378, 0, 14.91489
2369, 1040.2666, 0, -4.30706
2370, 1038.5439, 0, 24.601769
2371, 769.38241, 0, 60.975962
2372, 1215.7415, 44.97, -57.898243
2373, 1221.968, 29.967159, -55.833756
2374, 1235.8469, 44.997159, -48.114475
2375, 49.876639, 0, -209.02889
2376, 44.536324, 0, -198.87227
2377, -114.24271, 0, -180.49976
2378, -109.51855, 0, -169.59553
2379, 34.582909, 0, -186.19382
2380, 25.282127, 0, -180.21505
2381, 10.064129, 0, -173.94598
2382, -1.2275773, 0, -173.18083
2383, -15.772493, 0, -175.59546
2384, -27.932523, 0, -180.53473
2385, -46.289532, 0, -199.57043
2386, -51.164895, 0, -211.82046
2387, -51.597861, 0, -226.10255
2388, -50.11032, 0, -236.86607
2389, 52.12614, 0, -236.05335
2390, 52.834919, 0, -224.5251
2391, -204.09076, 0, -47.01127
2392, -193.96305, 0, -40.611142
2393, -108.86904, 0, -149.05921
2394, -113.04653, 0, -138.15526
2395, -119.1632, 0, -124.68985
2396, -127.12174, 0, -116.81656
2397, -143.04004, 0, -109.56415
2398, -154.29162, 0, -106.80108
2399, -172.00222, 0, -107.95179
2400, -183.52454, 0, -111.19058
2401, -197.52094, 0, -121.25412
2402, -205.53562, 0, -130.27091
2403, -161.14274, 0, 214.34441
2404, -128.1441, 0, -198.38494
2405, -121.37173, 0, -189.14845
2406, -182.26333, 0, 113.06684
2407, -170.02442, 0, 107.54961
2408, -183.55684, 0, -30.698148
2409, -177.47244, 0, -20.95141
2410, -172.8439, 0, -5.9556033
2411, -173.11029, 0, 5.0021116
2412, -178.09998, 0, 19.555225
2413, -184.00689, 0, 29.227118
2414, -194.85074, 0, 40.411597
2415, -206.0951, 0, 47.657399
2416, -229.50365, 0, 51.472399
2417, -240.58721, 0, 49.385283
2418, -240.21203, 0, -51.490267
2419, -228.327, 0, -53.003833
2420, -45.686094, 0, 200.33178
2421, -39.219625, 0, 191.83644
2422, -144.05267, 0, 105.98322
2423, -132.41644, 0, 111.35231
2424, -122.4591, 0, 121.85983
2425, -115.43025, 0, 130.07294
2426, -108.95139, 0, 142.54835
2427, -105.87032, 0, 154.19671
2428, -110.85227, 0, 176.41995
2429, -116.11263, 0, 186.19086
2430, -124.70376, 0, 192.23672
2431, -131.79967, 0, 198.91803
2432, -202.20058, 0, 128.52143
2433, -192.5554, 0, 120.71987
2434, -25.778914, 0, 187.20131
2435, -16.434443, 0, 182.90321
2436, -5.5718346, 0, 179.58648
2437, 4.5276292, 0, 179.23142
2438, 17.255179, 0, 180.79287
2439, 26.844738, 0, 185.16152
2440, 41.667491, 0, 192.21235
2441, 48.13339, 0, 201.03714
2442, 54.371088, 0, 217.57187
2443, 55.458893, 0, 229.4975
2444, -47.496367, 0, 255.72316
2445, -52.520415, 0, 245.64526
2446, -53.416649, 0, 229.23285
2447, -52.187571, 0, 217.48323
2448, 127.11436, 0, -176.83268
2449, 100.13043, 0, -181.86302
2450, -36.707759, 0, 287.2429
2451, -28.422871, 0, 275.18838
2452, -58.181528, 0, 283.40064
2453, 63.114191, 0, -278.02238
2454, 67.729699, 0, -260.7654
2455, -101.05551, 0, -99.91268
2456, -93.765778, 0, -118.64221
2457, -147.08918, 0, -45.895698
2458, -141.48915, 0, -68.707632
2459, -92.462177, 0, 119.85884
2460, -102.42559, 0, 103.97322
2461, 79.262758, 0, -220.82631
2462, 72.933065, 0, -243.63982
2463, -51.651292, 0, 139.90251
2464, -70.606784, 0, 138.97418
2465, -118.17803, 0, -91.764343
2466, 750.85568, 0, 97.699403
2467, -148.4741, 0, 210.2132
2468, -150.93718, 0, 219.82622
2469, -139.134, 0, 206.1736
2470, -38.056879, 0, 266.66616
2471, -51.629393, 0, 265.17229
2472, 57.585594, 0, -248.14996
2473, -118.45102, 0, -232.03207
2474, -133.03075, 0, -221.63702
2475, -207.88512, 0, -195.76019
2476, -102.19028, 0, -221.62428
2477, -101.6874, 0, -159.38537
2478, -95.332519, 0, -148.85755
2479, -95.982029, 0, -169.39386
2480, -191.5617, 0, 109.46563
2481, -204.3845, 0, 106.34087
2482, -194.09242, 0, 98.687841
2483, 809.51229, 0, -64.206724
2484, -214.87683, 0, -54.022879
2485, -202.23565, 0, -57.667582
2486, -226.47189, 0, -63.660145
2487, -270.597, 0, 30.617146
2488, -196.00169, 0, -109.46066
2489, 200.07525, 0, 140.73069
2490, 213.85388, 0, 91.369081
2491, -164.29468, 0, -98.246416
2492, -208.35144, 0, 181.25495
2493, -76.960709, 0, 249.13945
2494, -67.621016, 0, 272.45764
2495, -59.707239, 0, -219.31966
2496, 67.768298, 0, 272.93867
2497, 78.198579, 0, 249.70345
2498, -181.04338, 0, -40.74298
2499, 780.10425, 0, 129.03108
2500, 293.71157, 0, 55.822301
2501, 333.4964, 0, 87.5928
2502, -43.104236, 0, -180.21767
2503, -56.088977, 0, -185.68482
2504, -37.731969, 0, -166.64912
2505, 187.92008, 0, 189.6585
2506, -130.66578, 0, -104.34813
2507, 64.007344, 0, 238.29999
2508, 80.51548, 0, 232.89534
2509, -210.99604, 0, 170.77819
2510, -61.965115, 0, 237.81688
2511, -215.4167, 0, 159.60021
2512, -214.29192, 0, 148.05271
2513, -77.856943, 0, 232.72704
2514, -8.0153401, 0, -164.55155
2515, 46.918986, 0, -187.3535
2516, 62.523794, 0, -186.88185
2517, 52.57038, 0, -174.20339
2518, -108.63083, 0, -125.06597
2519, -66.529282, 0, -247.44546
2520, -72.499037, 0, -229.25889
2521, -22.223326, 0, -270.47334
2522, -35.075292, 0, -268.06198
2523, 134.02561, 0, -134.30056
2524, 25.922001, 0, 137.74315
2525, 5.3254769, 0, 140.34757
2526, -142.15078, 0, 58.979326
2527, -146.42657, 0, 37.896667
2528, -62.843875, 0, -146.00797
2529, -37.98764, 0, -149.3639
2530, -214.31604, 0, 83.911629
2531, -219.70879, 0, 106.52341
2532, -14.053844, 0, 141.69988
2533, -31.484677, 0, 137.9612
2534, 21.747574, 0, -168.40598
2535, 5.7715649, 0, -286.006
2536, 16.836129, 0, -275.60713
2537, -142.61799, 0, 91.885179
2538, -140.38654, 0, 74.663563
2539, -157.67409, 0, 69.406301
2540, -157.34453, 0, 99.188575
2541, 1044.4588, 0, 48.532759
2542, 1040.8558, 0, 76.405966
2543, -285.18747, 0, -8.8392837
2544, 1043.755, 0, -70.669359
2545, 1045.9659, 0, -39.400623
2546, -45.534053, 0, 155.98424
2547, 1221.7388, 29.967117, 55.923387
2548, 1235.4214, 14.997117, 48.428553
2549, 1215.4684, 14.97, 57.97178
2550, 60.086548, 0, 204.95715
2551, 79.821566, 0, 208.07866
2552, 1235.4214, 44.997117, 48.428553
2553, 1215.4684, 44.97, 57.97178
2554, 39.026097, 0, 181.37158
2555, 187.4631, 0, 50.496498
2556, -151.7229, 0, -28.567128
2557, -166.00345, 0, -48.158556
2558, -103.64416, 0, 166.88221
2559, -99.209516, 0, 179.55442
2560, -94.227566, 0, 157.33117
2561, -102.93259, 0, 132.17026
2562, -119.3688, 0, 109.18734
2563, -39.347189, 0, -257.36584
2564, -45.009267, 0, -265.77766
2565, -44.680799, 0, -247.60596
2566, -217.17807, 0, 117.3012
2567, 146.66118, 0, 131.34802
2568, 109.26407, 0, 127.23033
2569, -61.099761, 0, -258.18535
2570, -56.359871, 0, 204.25303
2571, 359.16146, 0, -87.720629
2572, 87.146467, 0, 127.21627
2573, 57.082629, 0, 138.90974
2574, 182.53922, 0, -61.753367
2575, -8.2710117, 0, -147.26632
2576, 24.455938, 0, -148.64176
2577, 59.83068, 0, -215.52817
2578, 161.21952, 0, 157.92421
2579, -80.467472, 0, -142.43379
2580, -70.527278, 0, -162.75789
2581, -12.114364, 0, 174.51458
2582, -166.00863, 0, -15.83418
2583, -166.36978, 0, 13.71474
2584, -182.20332, 0, 39.452333
2585, -207.38201, 0, 61.448493
2586, -220.42995, 0, 58.469081
2587, -257.54698, 0, -37.222761
2588, -249.15548, 0, -43.057785
2589, -36.417683, 0, 182.46645
2590, -115.00875, 0, 195.13801
2591, -108.84441, 0, 202.61814
2592, -117.43553, 0, 208.664
2593, -130.93421, 0, 208.43944
2594, -96.369, 0, 206.24976
2595, -87.159676, 0, 220.2025
2596, -72.164082, 0, 208.87993
2597, -93.942222, 0, 192.72377
2598, 11.475795, 0, 172.7593
2599, 6.0697244, 0, 161.26808
2600, 18.797274, 0, 162.82953
2601, -128.86983, 0, -209.10051
2602, -248.51424, 0, -75.22029
2603, -255.52783, 0, -60.910388
2604, 86.349744, 0, -163.41476
2605, 81.955872, 0, -192.17999
2606, -230.79055, 0, 65.263494
2607, -229.06184, 0, -77.450303
2608, 97.830058, 0, 153.68556
2609, 1092.2602, 0, 122.56486
2610, 1070.2089, 0, 107.6941
2611, 338.85621, 0, -35.388211
2612, 308.2779, 0, -82.454471
2613, -208.31397, 0, -180.8093
2614, -247.18897, 0, 68.82601
2615, -267.05121, 0, -38.620689
2616, -264.47129, 0, -52.477906
2617, -217.5699, 0, -135.13352
2618, -224.63486, 0, -120.54921
2619, -217.52488, 0, 128.70398
2620, -273.35902, 0, -21.842796
2621, -83.696451, 0, -173.94835
2622, -66.072854, 0, -177.52253
2623, -69.25815, 0, -196.87529
2624, -91.527605, 0, -184.15851
2625, -153.97691, 0, -81.291419
2626, -171.68751, 0, -82.442124
2627, -72.06607, 0, -214.9768
2628, -134.09633, 0, -84.511924
2629, 220.08602, 0, -52.199218
2630, -214.09985, 0, -105.89185
2631, -204.07873, 0, 73.463431
2632, -196.67792, 0, 85.114884
2633, -183.85512, 0, 88.239643
2634, -189.74389, 0, 62.651749
2635, -81.077198, 0, 151.2856
2636, -85.983314, 0, 132.33424
2637, 39.809997, 0, 140.89101
2638, 27.2792, 0, 154.48617
2639, -165.3989, 0, 40.994959
2640, -152.38714, 0, 25.169562
2641, -22.815928, 0, -149.68096
2642, 310.53137, 0, 3.8903945
2643, -213.10743, 0, -145.88023
2644, -214.85518, 0, -156.66819
2645, -211.00436, 0, -170.13904
2646, -177.08924, 0, -70.754779
2647, -187.40702, 0, -87.709777
2648, -82.049947, 0, -206.81451
2649, 271.15285, 0, 21.809854
2650, -168.58974, 0, 93.451569
2651, -147.09436, 0, -13.571322
2652, 76.304478, 0, -205.3301
2653, -5.988117, 0, 152.69062
2654, 1043.2108, 0, -21.775062
2655, -54.710685, 0, -244.34163
2656, -200.10345, 0, -95.828315
2657, -253.69847, 0, 52.700413
2658, -136.06844, 0, 226.75365
2659, 263.29659, 0, -63.258542
2660, -110.94221, 0, -188.25272
2661, -205.50517, 0, -84.140971
2662, -108.67838, 0, -199.53753
2663, -101.54935, 0, -190.88884
2664, -147.39745, 0, 10.616448
2665, 55.278744, 0, -154.43918
2666, -248.86552, 0, -54.208616
2667, -266.78922, 0, -30.067316
2668, -87.649117, 0, -132.10763
2669, 28.563778, 0, -268.94978
2670, 41.318449, 0, -262.00517
2671, 46.922774, 0, -253.17894
2672, 227.94228, 0, 32.869177
2673, -171.17523, 0, 79.878612
2674, -65.662604, 0, 191.72849
2675, -176.24275, 0, 52.179438
2676, -89.263777, 0, -195.44333
2677, 106.63327, 0, 174.18253
2678, 84.515673, 0, 174.16847
2679, -172.93947, 0, 64.194375
2680, -124.76986, 0, 215.91957
2681, 73.583867, 0, 191.54393
2682, 64.780655, 0, 171.04695
2683, 58.439828, 0, 155.65277
2684, 39.673936, 0, -154.91083
2685, -202.91523, 0, -70.350812
2686, -192.12917, 0, -63.339203
2687, 244.76208, 0, -19.062729
2688, -73.583742, 0, 177.14046
2689, -57.779531, 0, 172.51357
2690, -176.40966, 0, -58.07155
2691, 134.506, 0, 180.27583
2692, -118.79696, 0, -207.61697
2693, -109.40411, 0, -210.2531
2694, -37.612916, 0, 170.57226
2695, -24.172205, 0, 165.93712
2696, -254.42143, 0, 43.818885
2697, -12.538068, 0, -273.82878
2698, -4.1170318, 0, -276.67301
2699, -262.13891, 0, 38.401149
2700, 1215.7415, 14.97, -57.898243
2701, 1235.8469, 14.997159, -48.114475
2702, 1247.0394, 14.997159, -37.246445
2703, 1255.4596, 14.999537, -22.896119
2704, -13.309597, 0, 162.62039
2705, 32.68527, 0, 165.97739
2706, 47.508023, 0, 173.02822
2707, -86.73411, 0, 183.18603
2708, -215.61166, 0, -78.46935
2709, -92.071697, 0, -213.54484
2710, 1259.4877, 14.999537, -7.8242505
2711, 1259.4311, 14.999531, 8.2428962
2712, -78.851036, 0, 163.97111
2713, 1255.2604, 14.999531, 23.372862
2714, 1246.7093, 14.997117, 37.659592
2715, 53.044419, 14.22, 295.27325
2716, 53.044419, 44.22, 295.27325
2717, 26.688978, 44.931947, -298.81047
2718, 10.892209, 44.931947, -299.8022
2719, -2.7231928, 45.021506, -299.98764
2720, -17.451374, 45.021506, -299.49199
2721, -30.66399, 44.971639, -298.42875
2722, -44.742237, 44.971639, -296.64479
2723, -24.511171, 29.993145, -298.99699
2724, -63.422307, 44.963149, -293.21939
2725, -84.052304, 44.963149, -287.98474
2726, -56.451077, 29.934788, -294.64093
2727, -173.81182, 44.953793, -244.51882
2728, -186.46612, 44.953793, -235.01146
2729, -198.94399, 45.019876, -224.54685
2730, -210.89853, 45.019876, -213.35841
2731, -192.87639, 29.973669, -229.77968
2732, -222.08786, 44.981735, -201.68535
2733, -232.41589, 44.981735, -189.69147
2734, -216.56134, 30.001611, -207.60825
2735, -242.32664, 45.057977, -176.8553
2736, -252.20745, 45.057977, -162.45431
2737, -237.67202, 30.039712, -183.06287
2738, -262.52882, 45.0022, -145.18477
2739, -272.39108, 45.0022, -125.71037
2740, -258.05205, 30.060177, -153.00045
2741, -280.6517, 44.983961, -105.99351
2742, -287.61615, 44.983961, -85.305034
2743, -276.6863, 29.986161, -115.95124
2744, -292.85324, 45.367073, -65.092091
2745, -296.56866, 45.367073, -45.244143
2746, -298.72809, 45.367005, -27.595771
2747, -299.76776, 45.367005, -11.802085
2748, -299.96788, 45.070237, 4.3896605
2749, -299.35514, 45.070237, 19.659572
2750, -299.97143, 30.437242, -4.1400711
2751, -297.71397, 44.853999, 36.964757
2752, -294.2379, 44.853999, 58.515474
2753, -289.08055, 44.99694, 80.202451
2754, -281.55264, 44.99694, 103.5766
2755, -292.07204, 29.850938, 68.512216
2756, -271.71119, 44.938272, 127.17323
2757, -260.3999, 44.938272, 148.96944
2758, -277.47519, 29.935212, 114.05052
2759, -249.71808, 44.993167, 166.25546
2760, -240.27557, 44.993167, 179.63198
2761, -230.91568, 44.991435, 191.51487
2762, -221.96827, 44.991435, 201.81696
2763, -236.78658, 29.984602, 184.20672
2764, -211.8477, 44.958748, 212.41599
2765, -200.34977, 44.958748, 223.29346
2766, -217.36228, 29.950183, 206.76953
2767, -187.13172, 44.989068, 234.48181
2768, -173.16981, 44.989068, 244.97391
2769, -194.13139, 29.947816, 228.72036
2770, -158.65957, 44.907353, 254.61174
2771, -138.75821, 44.907353, 265.9815
2772, -166.40311, 29.896421, 249.61972
2773, -100.2752, 30, 282.74526
2774, -73.644123, 30, 290.82047
2775, -22.153008, 44.923046, 299.18096
2776, -6.8887318, 44.923046, 299.9209
2777, 9.7432282, 44.563729, 299.84174
2778, 25.543681, 44.563729, 298.91056
2779, 2.4784373, 29.486775, 299.98976
2780, 10.346699, 14.931947, -299.82152
2781, 26.688978, 14.931947, -298.81047
2782, -17.451374, 15.021506, -299.49199
2783, -3.2690174, 15.021506, -299.98219
2784, -45.28191, 14.971639, -296.56289
2785, -30.66399, 14.971639, -298.42875
2786, -85.099725, 14.963149, -287.67697
2787, -63.955716, 14.963149, -293.10351
2788, -159.8263, 14.815575, -253.88098
2789, -144.30348, 14.815575, -263.01427
2790, -186.89342, 14.953793, -234.67179
2791, -173.81182, 14.953793, -244.51882
2792, -210.89853, 15.019876, -213.35841
2793, -199.35223, 15.019876, -224.1845
2794, -232.76065, 14.981735, -189.26828
2795, -222.08786, 14.981735, -201.68535
2796, -251.91145, 15.057977, -162.91293
2797, -242.64803, 15.057977, -176.4141
2798, -272.1619, 15.0022, -126.20578
2799, -262.26422, 15.0022, -145.6622
2800, -287.61615, 14.983961, -85.305034
2801, -280.45838, 14.983961, -106.50398
2802, -296.40205, 15.367073, -46.323058
2803, -292.85324, 15.367073, -65.092091
2804, -299.72283, 15.367005, -12.892863
2805, -298.62569, 15.367005, -28.682661
2806, -299.39042, 15.070237, 19.114861
2807, -299.98187, 15.070237, 3.2980469
2808, -294.75806, 14.853999, 55.836251
2809, -297.78073, 14.853999, 36.423004
2810, -282.48326, 14.99694, 101.01092
2811, -289.79823, 14.99694, 77.569249
2812, -261.20916, 14.938272, 147.54583
2813, -272.85689, 14.938272, 124.6961
2814, -241.25251, 14.993167, 178.31776
2815, -250.62187, 14.993167, 164.8899
2816, -223.06658, 14.991435, 200.60235
2817, -231.95763, 14.991435, 190.25157
2818, -201.16101, 14.958748, 222.5629
2819, -213.00401, 14.958748, 211.25646
2820, -174.06012, 14.989068, 244.34212
2821, -187.98376, 14.989068, 233.79929
2822, -139.7252, 14.907353, 265.4748
2823, -159.58505, 14.907353, 254.0327
2824, -6.8887318, 14.923046, 299.9209
2825, -22.697333, 14.923046, 299.14015
2826, 25.543681, 14.563729, 298.91056
2827, 9.7432282, 14.563729, 299.84174
2828, 46.672516, 28.783729, 296.34722
2829, 2.3356919, 29.953454, -299.99091
2830, 55.728444, 30, -294.77846
2831, -95.088941, 29.922718, -284.53136
2832, -103.96398, 44.95957, -281.40983
2833, -124.15175, 44.95957, -273.105
2834, -104.98734, 14.95957, -281.02964
2835, -297.58165, 30.734078, -38.015269
2836, -159.8263, 44.815575, -253.88098
2837, -166.38666, 29.769367, -249.63069
2838, -142.86567, 44.815575, -263.79803
2839, -290.22698, 30.351033, -75.949315
2840, -256.85289, 29.931439, 155.00513
2841, -298.55664, 29.924236, 29.392782
2842, -59.679496, 15.03474, 294.00401
2843, -59.144455, 45.03474, 294.11211
2844, -37.60122, 45.03474, 297.63425
2845, -125.64065, 14.95957, -272.42325
2846, -133.75389, 29.775144, -268.53286
2847, 37.397526, 30, -297.65992
2848, -38.142705, 15.03474, 297.56534
2849, -29.634587, 29.957786, 298.53273
2850, -126.53857, 30, 272.00734
2851, 1130.5939, 30, -150.5265
2852, 1165.8649, 30, -150.12735
2853, 1067.4592, 30, -151.9203
2854, 1099.8774, 30, -151.09571
2855, 993.55068, 30, -154.66044
2856, 1031.068, 30, -153.11997
2857, 923.67118, 30, -158.35272
2858, 958.88794, 30, -156.35797
2859, 865.20325, 30, -162.26659
2860, 895.28243, 30, -160.15913
2861, 797.15521, 30, -167.77046
2862, 833.4373, 30, -164.7087
2863, 691.86351, 30, -178.30644
2864, 741.6485, 30, -173.01813
2865, 595.86552, 30, -190.06378
2866, 643.26875, 30, -184.00063
2867, 500.13752, 30, -203.84777
2868, 547.40199, 30, -196.78392
2869, 233.34296, 30, -253.28901
2870, 281.77752, 30, -243.09276
2871, 153.42676, 30, -271.31507
2872, 187.24067, 30, -263.50434
2873, 97.573147, 30, -284.81081
2874, 122.43747, 30, -278.71121
2875, 341.49323, 30, -231.27202
2876, 452.94942, 30, -211.40493
2877, 399.12028, 30, -220.6447
2878, 1232.4915, 30, -146.43873
2879, 1233.8702, 30, 146.12601
2880, 1265.9909, 30, 134.70414
2881, 1295.9762, 30, 115.27604
2882, 1336.9999, 30, 61.082238
2883, 1347.4307, 30, 27.644167
2884, 1349.9993, 30, -0.47123812
2885, 1346.5401, 30, -32.031291
2886, 1336.5159, 30, -62.156337
2887, 1320.094, 30, -89.874502
2888, 1292.8641, 30, -117.79754
2889, 1264.293, 30, -135.52274
2890, 1321.075, 30, 88.548592
2891, 153.98061, 30, 271.18496
2892, 122.99039, 30, 278.57725
2893, 460.24714, 30, 210.20314
2894, 407.52376, 30, 219.15864
2895, 559.22943, 30, 195.09514
2896, 513.63409, 30, 201.77915
2897, 650.04572, 30, 183.17489
2898, 606.5821, 30, 188.64902
2899, 747.30947, 30, 172.45167
2900, 699.21443, 30, 177.49092
2901, 832.30312, 30, 164.8
2902, 794.32172, 30, 168.02182
2903, 903.23014, 30, 159.63554
2904, 868.60773, 30, 162.01806
2905, 977.63832, 30, 155.40699
2906, 939.57361, 30, 157.41824
2907, 1064.0472, 30, 152.02047
2908, 1025.3827, 30, 153.33359
2909, 1132.3005, 30, 150.50093
2910, 1101.5837, 30, 151.05868
2911, 1167.0027, 30, 150.119
2912, 188.35032, 30, 263.25259
2913, 234.45515, 30, 253.04873
2914, 285.6793, 30, 242.29516
2915, 110.06466, 14.404063, 281.72801
2916, 86.321008, 14.404063, 287.61968
2917, 344.84637, 30, 230.63272
2918, 86.321008, 28.624063, 287.61968
2919, 86.321008, 44.404063, 287.61968
2920, 111.72237, 44.404063, 281.3217
2921, 13.566871, 60, -290.41953
2922, 29.347989, 60, -289.27786
2923, -40.89437, 60, -286.83262
2924, -26.820174, 60, -288.61696
2925, -111.69199, 60, -255.46478
2926, -91.499701, 60, -263.72051
2927, -178.69668, 60, -226.70379
2928, -166.04987, 60, -236.21197
2929, -227.17661, 60, -180.64285
2930, -216.84595, 60, -192.6272
2931, -256.55374, 60, -117.41104
2932, -246.68515, 60, -136.86604
2933, -281.49715, 60, -42.991414
2934, -277.80928, 60, -62.832865
2935, -265.51494, 60, 98.260002
2936, -273.19615, 60, 74.957443
2937, -229.54114, 60, 173.01143
2938, -239.03296, 60, 159.67734
2939, -165.22221, 60, 237.26969
2940, -179.19496, 60, 226.80437
2941, -81.174738, 60, 267.37035
2942, -107.39126, 60, 258.12636
2943, 1085.7734, 60, -122.73024
2944, 1116.4879, 60, -122.06554
2945, 937.01406, 60, -117.77343
2946, 971.67145, 60, -115.97462
2947, 885.29836, 60, -125.90445
2948, 913.68309, 60, -124.03804
2949, 831.17688, 60, -122.22085
2950, 862.93741, 60, -119.71161
2951, 614.96107, 60, -146.69988
2952, 663.53063, 60, -140.80037
2953, 302.91672, 60, -196.34386
2954, 362.69275, 60, -184.83914
2955, 132.4784, 60, -245.27468
2956, 163.49126, 60, -237.97882
2957, 106.68055, 60, 262.04659
2958, 81.278996, 60, 268.34332
2959, 266.82784, 60, 205.53758
2960, 215.64229, 60, 216.46927
2961, 596.19048, 60, 153.30514
2962, 548.84976, 60, 159.83359
2963, 785.01967, 60, 135.40094
2964, 738.01109, 60, 139.86289
2965, 929.87073, 60, 123.14885
2966, 893.52645, 60, 125.34805
2967, 173.76481, 60, -22.942707
2968, 165.15715, 60, -57.829038
2969, 145.36859, 60, -104.44905
2970, 124.00776, 60, -129.53907
2971, 95.777023, 60, -145.94776
2972, 75.929035, 60, -156.61693
2973, 4.6029653, 60, -159.21788
2974, -10.451218, 60, -159.26518
2975, -67.625303, 60, -153.79685
2976, -85.237068, 60, -144.89279
2977, -97.621226, 60, -123.86608
2978, -111.37254, 60, -111.74266
2979, -132.33246, 60, -97.28912
2980, -143.16235, 60, -81.353416
2981, -150.99491, 60, -63.411755
2982, -157.55191, 60, -44.550822
2983, -159.62305, 60, -25.055321
2984, -161.13392, 60, -10.077073
2985, -159.44763, 60, 8.873848
2986, -157.79233, 60, 24.54404
2987, -161.07252, 60, 44.635191
2988, -153.56401, 60, 64.889872
2989, -139.98709, 60, 81.404352
2990, -130.56477, 60, 94.900884
2991, -112.42432, 60, 113.36019
2992, -100.66424, 60, 124.19689
2993, -87.721422, 60, 135.70945
2994, -73.069819, 60, 144.18902
2995, -57.583941, 60, 151.40744
2996, -39.081564, 60, 156.78288
2997, -12.927064, 60, 158.55113
2998, 2.3410685, 60, 159.34328
2999, 19.091207, 60, 160.52956
3000, 35.340533, 60, 157.90357
3001, 65.678863, 60, 163.37501
3002, 88.400215, 60, 152.72672
3003, 118.9134, 60, 143.98925
3004, 141.20471, 60, 119.72215
3005, 174.77046, 60, 69.953489
3006, 184.74016, 60, 32.589607
3007, 698.21871, 60, 54.735402
3008, 706.28863, 60, 24.681004
3009, 659.18696, 60, 108.24766
3010, 681.06264, 60, 86.371974
3011, 626.24488, 60, 145.23522
3012, 518.95865, 60, 151.85784
3013, 454.83113, 60, 95.637915
3014, 476.96427, 60, 117.77105
3015, 425.41274, 60, 31.592465
3016, 433.3885, 60, 61.483571
3017, 434.11684, 60, -63.108214
3018, 426.04692, 60, -33.053816
3019, 474.8823, 60, -117.59174
3020, 452.84333, 60, -95.621898
3021, 585.09517, 60, -154.76951
3022, 711.23309, 60, -15.12483
3023, 703.25733, 60, -45.015936
3024, 997.05103, 60, 37.825754
3025, 1003.1035, 60, 15.284956
3026, 974.57638, 60, 85.615277
3027, 991.10561, 60, 69.137894
3028, 815.5743, 60, 67.331645
3029, 832.05169, 60, 83.860875
3030, 792.588, 60, 17.369562
3031, 798.56982, 60, 39.787891
3032, 801.07192, 60, -36.110433
3033, 795.0901, 60, -13.692104
3034, 1007.9963, 60, -11.77527
3035, 1002.0847, 60, -34.07091
3036, 34.947926, 60, -218.02956
3037, 36.941866, 60, -225.50234
3038, 22.343646, 60, -197.71815
3039, 27.795358, 60, -203.20423
3040, 4.4319483, 60, -192.02527
3041, 12.127666, 60, -194.06575
3042, -13.280198, 60, -195.16974
3043, -5.8265457, 60, -193.10546
3044, -28.469315, 60, -206.72662
3045, -23.034864, 60, -201.22344
3046, -35.290768, 60, -223.6007
3047, -33.320241, 60, -216.16882
3048, -33.896141, 60, -241.67461
3049, -35.913621, 60, -234.16101
3050, -22.908051, 60, -255.85344
3051, -28.417794, 60, -250.36098
3052, -5.9263241, 60, -262.87117
3053, -13.399101, 60, -260.87723
3054, 11.428829, 60, -261.45755
3055, 3.9152297, 60, -263.47503
3056, 27.574965, 60, -251.27214
3057, 22.082504, 60, -256.78189
3058, 35.080284, 60, -235.48794
3059, 33.086344, 60, -242.96071
3060, -129.50042, 60, -176.34872
3061, -133.38676, 60, -183.08821
3062, -124.01703, 60, -160.03893
3063, -124.00481, 60, -167.81866
3064, -133.47036, 60, -137.07746
3065, -129.56286, 60, -143.80471
3066, -148.70209, 60, -127.17476
3067, -141.99597, 60, -131.02784
3068, -166.84682, 60, -125.25849
3069, -159.06709, 60, -125.24627
3070, -183.26519, 60, -132.91149
3071, -176.57121, 60, -129.03737
3072, -194.74125, 60, -147.1635
3073, -190.85491, 60, -140.424
3074, -197.2786, 60, -165.62293
3075, -197.29082, 60, -157.8432
3076, -190.77043, 60, -183.20175
3077, -194.64456, 60, -176.50777
3078, -175.81107, 60, -196.62143
3079, -182.55056, 60, -192.73508
3080, -156.86796, 60, -196.9549
3081, -164.64769, 60, -196.96712
3082, -140.32595, 60, -189.60212
3083, -147.01993, 60, -193.47624
3084, -214.6923, 60, -33.711956
3085, -222.2059, 60, -35.729436
3086, -199.57323, 60, -22.197419
3087, -205.0657, 60, -27.707163
3088, -193.49167, 60, -6.2221686
3089, -195.48553, 60, -13.742069
3090, -193.53406, 60, 10.875646
3091, -191.51665, 60, 3.4091703
3092, -203.05659, 60, 27.899601
3093, -197.54685, 60, 22.40714
3094, -221.20846, 60, 38.274802
3095, -213.73568, 60, 36.280863
3096, -239.97744, 60, 33.84009
3097, -232.46384, 60, 35.85757
3098, -255.37985, 60, 23.699052
3099, -249.88739, 60, 29.208796
3100, -265.76533, 60, 7.0628102
3101, -263.77139, 60, 14.535587
3102, -263.73071, 60, -16.108646
3103, -265.74819, 60, -8.5950462
3104, -249.26939, 60, -28.3736
3105, -254.77913, 60, -22.881139
3106, -233.85219, 60, -35.767117
3107, -241.32497, 60, -33.773177
3108, -175.80536, 60, 127.1066
3109, -182.54485, 60, 130.99294
3110, -155.51728, 60, 123.14487
