1784, 779, 1312, 354, 1082, 7225, 7545, 3114, 
5765, 7223, 4632
1785, 926, 905, 902, 921, 4896, 3833, 4898, 
3938, 7797, 4969
1786, 508, 611, 1172, 612, 2394, 7837, 7458, 
2395, 2518, 5256
1787, 1317, 42, 435, 1107, 6562, 1825, 6042, 
6208, 4693, 4694
1788, 262, 1155, 26, 1, 5770, 5771, 1586, 
2873, 6902, 1571
1789, 921, 898, 902, 55, 4968, 3808, 4969, 
3921, 6923, 6924
1790, 990, 417, 1001, 1231, 4268, 4266, 4325, 
7838, 7750, 5967
1791, 1190, 572, 1295, 541, 7229, 7230, 7228, 
7839, 2619, 5321
1792, 408, 896, 281, 915, 6983, 3766, 5026, 
3885, 6984, 5027
1793, 294, 947, 932, 930, 4035, 6448, 7840, 
5756, 5755, 4014
1794, 541, 572, 459, 1190, 2619, 2277, 2512, 
7839, 7229, 5288
1795, 1052, 519, 180, 1042, 7811, 2026, 4506, 
4512, 7805, 4473
1796, 1316, 699, 882, 783, 6233, 3631, 7543, 
6363, 3545, 3628
1797, 1174, 1252, 613, 1254, 7552, 7351, 6634, 
6643, 5538, 6644
1798, 1300, 629, 1295, 572, 5350, 5351, 5349, 
7227, 2566, 7230
1799, 358, 1099, 784, 1100, 4700, 7496, 3124, 
4702, 4704, 7053
1800, 122, 826, 148, 469, 7841, 6453, 2188, 
1913, 6463, 2186
1801, 16, 431, 184, 524, 1820, 4543, 1494, 
2035, 5054, 2036
1802, 1077, 1304, 1087, 190, 7828, 7190, 4656, 
4617, 7806, 4650
1803, 1277, 291, 413, 30, 7842, 4940, 7394, 
7393, 1619, 4942
1804, 1297, 432, 1295, 433, 5339, 6922, 6919, 
7356, 1822, 7444
1805, 486, 409, 281, 138, 6821, 5025, 6120, 
1951, 3888, 5605
1806, 621, 1299, 659, 648, 7611, 7540, 2634, 
2675, 6118, 2679
1807, 1297, 1296, 1301, 1295, 7629, 5359, 7355, 
6919, 5348, 5361
1808, 408, 281, 385, 29, 5026, 3746, 7107, 
5366, 1608, 1734
1809, 534, 1088, 1086, 1311, 5271, 4653, 5839, 
5267, 5273, 7829
1810, 1099, 784, 1108, 1318, 7496, 7054, 4743, 
6952, 4992, 7843
1811, 1104, 539, 1321, 1096, 6353, 6366, 7415, 
4724, 6340, 5312
1812, 591, 1187, 133, 1188, 7581, 6168, 2337, 
7582, 6605, 7844
1813, 824, 679, 241, 698, 7063, 2760, 3221, 
3385, 7066, 2937
1814, 724, 463, 598, 653, 5865, 2356, 5866, 
6797, 2691, 2677
1815, 533, 192, 1078, 191, 2054, 4619, 7845, 
2053, 1503, 4620
1816, 1236, 1239, 993, 1005, 5807, 5804, 5803, 
7126, 7127, 4315
1817, 1251, 642, 593, 611, 6344, 2579, 7325, 
7572, 2478, 2668
1818, 1168, 611, 507, 642, 7573, 2393, 7279, 
7340, 2478, 2477
1819, 784, 1099, 1108, 1100, 7496, 4743, 7054, 
7053, 4704, 4744
1820, 1295, 434, 433, 1103, 7746, 1823, 7444, 
5324, 4716, 4715
1821, 266, 830, 267, 114, 3249, 3248, 1591, 
2886, 5853, 2887
1822, 711, 287, 1251, 286, 2976, 6433, 7154, 
2975, 1614, 7502
1823, 252, 468, 319, 118, 7846, 7847, 2946, 
2855, 1905, 7848
1824, 1294, 1296, 1301, 1298, 6286, 5359, 7799, 
7800, 7628, 7802
1825, 556, 263, 810, 1361, 7849, 3419, 7487, 
7850, 7851, 7823
1826, 1197, 860, 1341, 1337, 7096, 5780, 6370, 
6623, 6701, 6700
1827, 839, 264, 810, 556, 3420, 3418, 3439, 
7488, 7852, 7487
1828, 1105, 1109, 1322, 1111, 4736, 6264, 7495, 
4749, 4752, 6265
1829, 1303, 1302, 1089, 1092, 7853, 7854, 6360, 
7595, 7304, 4664
1830, 1066, 1291, 774, 1067, 7813, 5971, 7584, 
4567, 4878, 5970
1831, 80, 79, 671, 455, 1375, 2799, 2798, 
1864, 1863, 5818
1832, 1029, 1263, 1028, 760, 6480, 7025, 4418, 
5915, 6514, 5914
1833, 1302, 1079, 1089, 1092, 7303, 4660, 7854, 
7304, 4665, 4664
1834, 1103, 1109, 433, 1295, 4735, 4737, 4715, 
5324, 5038, 7444
1835, 430, 1280, 1062, 1071, 7855, 7857, 4551, 
4586, 7856, 4589
1836, 1079, 1297, 1089, 433, 7858, 7354, 4660, 
4624, 7356, 4655
1837, 717, 648, 1299, 1183, 6250, 6118, 5007, 
5009, 7233, 5008
1838, 1057, 1181, 1052, 1042, 7834, 7810, 4537, 
4531, 7809, 4512
1839, 1190, 698, 240, 679, 7405, 2938, 7407, 
5286, 7066, 2759
1840, 621, 1183, 523, 579, 7612, 5072, 2415, 
2585, 7104, 2586
1841, 603, 1168, 1223, 1169, 7638, 7232, 7859, 
7403, 7639, 6638
1842, 775, 1291, 696, 850, 4880, 7860, 3472, 
3467, 6567, 3544
1843, 273, 141, 102, 101, 6383, 1888, 2895, 
2896, 1887, 1398
1844, 1319, 1100, 1108, 1111, 7055, 4744, 7056, 
5418, 4746, 4751
1845, 1337, 860, 1336, 1197, 6701, 7696, 6891, 
6623, 7096, 7861
1846, 603, 1168, 642, 1223, 7638, 7340, 2479, 
7859, 7232, 6343
1847, 1073, 1076, 1284, 1285, 4608, 7568, 7483, 
5148, 5146, 7484
1848, 1318, 681, 1108, 1104, 7144, 7088, 7843, 
7780, 7414, 4734
1849, 1079, 1302, 1089, 1297, 7303, 7854, 4660, 
7858, 5732, 7354
1850, 988, 1234, 1003, 1241, 7681, 7273, 4319, 
5870, 7272, 5869
1851, 101, 273, 729, 272, 2896, 3256, 6469, 
2893, 1599, 3259
1852, 71, 1241, 569, 664, 7862, 6303, 2134, 
2782, 6372, 6142
1853, 1078, 1087, 532, 191, 4658, 7807, 7863, 
4620, 4649, 2052
1854, 926, 914, 905, 921, 3939, 6835, 4896, 
3938, 3926, 7797
1855, 484, 1212, 599, 646, 7698, 5711, 2363, 
2665, 6870, 2604
1856, 505, 504, 168, 1244, 2203, 1996, 1997, 
7714, 7665, 5809
1857, 270, 463, 575, 98, 7864, 2505, 7865, 
2912, 1883, 2155
1858, 93, 688, 1203, 246, 2842, 5044, 5045, 
2774, 2843, 5920
1859, 1161, 606, 1224, 1220, 5673, 5677, 7866, 
5671, 5670, 5678
1860, 1057, 1179, 1045, 1181, 6876, 6878, 4536, 
7834, 5718, 7867
1861, 60, 401, 62, 959, 3979, 1773, 1756, 
5374, 6630, 5375
1862, 797, 1135, 1136, 369, 6075, 4848, 7690, 
3150, 4844, 4846
1863, 1273, 341, 1055, 1045, 7761, 4513, 7600, 
6877, 4482, 4517
1864, 782, 882, 1317, 857, 3629, 6207, 6210, 
3486, 3630, 7544
1865, 401, 951, 935, 400, 7155, 7082, 3978, 
1772, 7689, 3977
1866, 28, 1360, 1361, 3, 5843, 6130, 6926, 
1594, 6127, 6126
1867, 439, 1196, 1325, 1323, 7515, 6003, 5377, 
7687, 5023, 6005
1868, 255, 155, 120, 254, 5736, 1910, 2862, 
1578, 6970, 2859
1869, 1307, 192, 533, 534, 5438, 2054, 7868, 
5266, 2055, 2232
1870, 320, 493, 739, 33, 7869, 7871, 3035, 
1653, 7870, 3034
1871, 1174, 756, 1253, 1173, 6914, 6964, 6963, 
6915, 6916, 7216
1872, 1126, 1197, 1198, 1339, 7872, 7640, 5480, 
7873, 7653, 6047
1873, 244, 683, 699, 825, 2770, 7833, 2939, 
3225, 5241, 3386
1874, 798, 369, 1136, 370, 3153, 4846, 7375, 
3152, 1712, 4847
1875, 299, 130, 477, 937, 7614, 1933, 6137, 
6136, 3983, 5764
1876, 1013, 756, 1012, 335, 6975, 4874, 4354, 
4351, 3068, 4349
1877, 1274, 1276, 290, 715, 7456, 6596, 6791, 
6792, 5515, 2983
1878, 1134, 1143, 1133, 1348, 4126, 4575, 4576, 
5585, 5397, 5399
1879, 1332, 362, 789, 1115, 7793, 3134, 7875, 
7874, 4770, 7876
1880, 1348, 795, 1133, 796, 5573, 6296, 5399, 
5572, 3361, 7317
1881, 365, 793, 44, 1119, 3143, 3142, 1707, 
4780, 7098, 4781
1882, 23, 210, 447, 1361, 1526, 2549, 1844, 
6760, 7112, 5469
1883, 293, 930, 946, 954, 5250, 7086, 4032, 
4055, 5757, 4077
1884, 1195, 649, 1192, 1333, 7205, 7877, 7426, 
6100, 5421, 7878
1885, 882, 1107, 1316, 783, 6206, 6364, 7543, 
3628, 5550, 6363
1886, 1332, 790, 789, 362, 5455, 3355, 7875, 
7793, 3137, 3134
1887, 1320, 1102, 1295, 787, 5034, 5035, 5037, 
7482, 5992, 6921
1888, 210, 556, 1151, 1361, 2100, 7879, 2548, 
7112, 7850, 6927
1889, 56, 53, 391, 64, 3872, 1742, 6298, 
1780, 1759, 3849
1890, 115, 559, 114, 267, 2164, 2163, 1412, 
2888, 6725, 2887
1891, 1195, 649, 631, 1192, 7205, 2704, 5426, 
7426, 7877, 7880
1892, 1134, 368, 796, 367, 4842, 3148, 7504, 
4841, 1710, 3149
1893, 876, 1220, 1223, 1222, 6768, 5692, 6769, 
6866, 7076, 7110
1894, 916, 592, 134, 481, 4933, 2339, 3891, 
4931, 2338, 1942
1895, 1168, 508, 611, 1172, 7278, 2394, 7573, 
6860, 7458, 7837
1896, 1253, 1173, 756, 1012, 7216, 6916, 6964, 
7215, 7218, 4874
1897, 920, 56, 904, 391, 3924, 6194, 7198, 
7197, 6298, 3794
1898, 534, 1313, 1311, 1086, 5782, 5613, 5267, 
5839, 5039, 7829
1899, 390, 918, 894, 410, 7101, 6888, 3772, 
5519, 3897, 7881
1900, 603, 1169, 616, 506, 7403, 7032, 2660, 
2377, 7397, 2405
1901, 687, 73, 451, 74, 2834, 1852, 7882, 
2845, 1369, 1853
1902, 535, 193, 437, 1086, 2057, 4621, 5274, 
5829, 4646, 4645
1903, 1243, 1206, 740, 414, 7525, 6467, 6827, 
7722, 5496, 6468
1904, 1092, 1303, 1302, 1305, 7595, 7853, 7304, 
7420, 7596, 7883
1905, 530, 1301, 629, 541, 7749, 5360, 2433, 
2240, 7884, 2432
1906, 1187, 1304, 1309, 1305, 7885, 7191, 7346, 
7249, 7599, 7520
1907, 1187, 1294, 1304, 1305, 6604, 7177, 7885, 
7249, 7424, 7599
1908, 773, 1066, 774, 349, 7758, 7584, 3339, 
3102, 4561, 3105
1909, 589, 1195, 1338, 1333, 7204, 6096, 7886, 
5420, 6100, 6097
1910, 1303, 1294, 1304, 531, 7887, 7177, 7597, 
6355, 7170, 7179
1911, 1229, 978, 418, 1163, 7265, 4214, 7888, 
7266, 7202, 7201
1912, 1320, 698, 679, 1319, 7186, 7066, 7889, 
5416, 7067, 7065
1913, 581, 705, 464, 831, 6498, 6288, 2295, 
7010, 3391, 4965
1914, 463, 269, 98, 270, 6213, 2891, 1883, 
7864, 1596, 2912
1915, 269, 463, 98, 97, 6213, 1883, 2891, 
2892, 1882, 1394
1916, 159, 1213, 971, 495, 5668, 5448, 4189, 
1977, 5309, 5449
1917, 1027, 760, 337, 1028, 6511, 3077, 4412, 
4415, 5914, 4413
1918, 1160, 1216, 1158, 604, 6143, 7493, 5302, 
6145, 5346, 7494
1919, 666, 225, 818, 1166, 2724, 3205, 7891, 
7890, 7892, 4924
1920, 1044, 1055, 1271, 426, 4538, 7765, 7763, 
4481, 4479, 7824
1921, 100, 464, 271, 831, 1886, 7080, 2917, 
4966, 4965, 3258
1922, 1180, 766, 767, 715, 5403, 3332, 6686, 
5402, 3623, 3672
1923, 765, 1181, 766, 1045, 7106, 5405, 3331, 
7893, 7867, 7176
1924, 709, 586, 1209, 473, 7894, 7471, 7453, 
5581, 2324, 7473
1925, 915, 896, 281, 282, 6984, 3766, 5027, 
6315, 3769, 1609
1926, 265, 466, 113, 112, 5330, 1901, 2884, 
2883, 1900, 1410
1927, 520, 1180, 521, 619, 7895, 4972, 2219, 
2410, 4971, 2411
1928, 463, 269, 270, 725, 6213, 1596, 7864, 
7241, 3255, 3254
1929, 1171, 1247, 641, 1165, 5984, 5983, 5676, 
6334, 7070, 7702
1930, 735, 149, 568, 150, 7675, 2130, 6292, 
7725, 1453, 2127
1931, 1047, 1180, 767, 1182, 7896, 6686, 7897, 
7616, 4973, 6617
1932, 132, 133, 479, 1187, 1432, 1938, 1937, 
6169, 6168, 7898
1933, 775, 1291, 774, 696, 4880, 5971, 3340, 
3472, 7860, 3473
1934, 288, 1170, 877, 712, 6111, 7589, 3602, 
2978, 6109, 3608
1935, 409, 915, 281, 138, 3886, 5027, 5025, 
3888, 3906, 5605
1936, 1322, 1319, 1111, 1320, 6689, 5418, 6265, 
6263, 5416, 5415
1937, 413, 916, 481, 290, 3894, 4931, 7392, 
4944, 7261, 6594
1938, 787, 1102, 1295, 432, 5992, 5035, 6921, 
6920, 4710, 6922
1939, 1165, 866, 692, 819, 7004, 3527, 7002, 
6789, 3526, 3381
1940, 819, 687, 692, 1165, 7899, 7900, 3381, 
6789, 7291, 7002
1941, 686, 1165, 687, 819, 6331, 7291, 2846, 
4895, 6789, 7899
1942, 1167, 596, 1, 1155, 6504, 2453, 6492, 
7449, 7672, 6902
1943, 1338, 131, 589, 1333, 5762, 2333, 7886, 
6097, 7268, 5420
1944, 866, 578, 1165, 1227, 6986, 7701, 7004, 
6865, 7009, 7003
1945, 20, 203, 1342, 547, 1517, 7647, 7901, 
2082, 2081, 5510
1946, 1173, 1255, 1257, 1015, 7602, 6906, 5218, 
5220, 7138, 5194
1947, 1259, 615, 1176, 1260, 7290, 7903, 6961, 
6962, 7902, 5357
1948, 376, 47, 806, 1358, 1721, 3172, 3171, 
4918, 6899, 7585
1949, 156, 253, 119, 254, 6058, 2857, 2319, 
7079, 1577, 2860
1950, 1246, 505, 11, 168, 4937, 1998, 7904, 
5808, 1997, 1475
1951, 1238, 70, 503, 569, 6037, 2535, 5959, 
6141, 2133, 2698
1952, 775, 1067, 350, 774, 4879, 4564, 3107, 
3340, 5970, 3104
1953, 1021, 1019, 1009, 1249, 4393, 4375, 4394, 
5663, 6380, 5662
1954, 1252, 638, 592, 1274, 7349, 2458, 7350, 
7551, 4927, 7905
1955, 1267, 1265, 1038, 1268, 5187, 7577, 5653, 
5188, 5190, 5913
1956, 1260, 615, 585, 1259, 7902, 2630, 7579, 
6962, 7290, 7549
1957, 1029, 1263, 1041, 1028, 6480, 6482, 4457, 
4418, 7025, 4456
1958, 1302, 776, 777, 1298, 5733, 3342, 7906, 
7776, 6023, 7371
1959, 1264, 1036, 1039, 1262, 6895, 4449, 6783, 
6894, 6893, 6308
1960, 1262, 1036, 1026, 1258, 6893, 4445, 6309, 
6807, 6929, 6930
1961, 1176, 1261, 615, 1259, 7786, 6834, 7903, 
6961, 7787, 7290
1962, 969, 941, 968, 940, 5488, 5489, 4111, 
6283, 4011, 5183
1963, 413, 134, 481, 916, 3889, 1942, 7392, 
3894, 3891, 4931
1964, 647, 649, 631, 1195, 2653, 2704, 2599, 
5425, 7205, 5426
1965, 1279, 852, 1278, 1184, 4960, 7907, 5200, 
4962, 4961, 7771
1966, 427, 1271, 1270, 1067, 7908, 4903, 7909, 
4571, 4875, 7910
1967, 1184, 1287, 1286, 1281, 7911, 5078, 7679, 
7773, 7825, 7827
1968, 1054, 428, 1272, 1042, 4510, 6009, 6083, 
4525, 4504, 6085
1969, 1353, 208, 552, 553, 7072, 2092, 7073, 
6754, 2093, 2251
1970, 621, 522, 1183, 620, 2414, 5074, 7612, 
2584, 2413, 7912
1971, 1185, 674, 82, 1289, 7753, 2805, 7913, 
7754, 5154, 5152
1972, 799, 370, 1352, 1137, 3155, 6257, 5385, 
5384, 4849, 5386
1973, 1270, 1074, 1292, 1068, 7914, 7389, 7245, 
6000, 4592, 7244
1974, 1340, 545, 546, 202, 5836, 2244, 7658, 
5838, 2078, 2079
1975, 1219, 324, 744, 743, 7467, 3045, 6530, 
6248, 3042, 3308
1976, 438, 1326, 43, 1125, 5840, 6695, 1829, 
4766, 5842, 4765
1977, 1289, 1282, 1284, 1285, 7090, 6575, 7091, 
7915, 7029, 7484
1978, 633, 1342, 634, 1337, 6675, 5511, 2550, 
6738, 6405, 6402
1979, 1116, 1332, 1115, 362, 7792, 7874, 4773, 
4771, 7793, 4770
1980, 813, 559, 814, 267, 6390, 5317, 3377, 
3555, 6725, 3251
1981, 773, 1065, 1285, 1288, 6668, 5147, 6669, 
6663, 7756, 7757
1982, 468, 739, 816, 320, 7916, 3233, 7918, 
7917, 3035, 3196
1983, 1177, 673, 1185, 696, 5211, 5214, 5212, 
7607, 7477, 7919
1984, 696, 850, 1291, 1177, 3544, 6567, 7860, 
7607, 7920, 4899
1985, 1177, 234, 672, 673, 7605, 2742, 6666, 
5211, 2744, 2839
1986, 518, 529, 1293, 623, 2228, 7921, 6068, 
2419, 2418, 7922
1987, 630, 1192, 631, 649, 5531, 7880, 2581, 
2695, 7877, 2704
1988, 648, 621, 1183, 620, 2675, 7612, 7233, 
2639, 2584, 7912
1989, 769, 1299, 1278, 1183, 5005, 5197, 5879, 
5006, 5008, 7103
1990, 290, 1274, 714, 289, 6791, 5567, 2982, 
1617, 7553, 2981
1991, 289, 1276, 481, 290, 7670, 6593, 4932, 
1617, 6596, 6594
1992, 916, 289, 481, 290, 4935, 4932, 4931, 
7261, 1617, 6594
1993, 1268, 178, 516, 517, 7465, 2020, 7707, 
5654, 2021, 2215
1994, 364, 1118, 1339, 792, 4777, 5246, 4958, 
3141, 6369, 4959
1995, 1354, 801, 250, 701, 6652, 3230, 7923, 
5445, 3366, 2944
1996, 563, 1356, 564, 217, 5789, 5164, 2264, 
2117, 5155, 2120
1997, 104, 706, 601, 465, 6382, 6394, 2499, 
1891, 5596, 2466
1998, 757, 1173, 756, 880, 6817, 6916, 3322, 
3615, 6554, 3616
1999, 534, 193, 535, 1086, 2056, 2057, 2233, 
5839, 4646, 5829
2000, 1348, 96, 580, 221, 7719, 2293, 7093, 
7654, 2715, 7655
2001, 416, 494, 1159, 1213, 7924, 5940, 4884, 
5669, 7441, 7452
2002, 926, 903, 895, 910, 5553, 3791, 4897, 
6271, 3821, 3820
2003, 474, 1209, 586, 128, 7925, 7471, 2331, 
1927, 7472, 2325
2004, 782, 783, 356, 1107, 3348, 3123, 3120, 
6209, 5550, 4730
2005, 1218, 496, 605, 497, 6521, 2381, 7455, 
6545, 2195, 2382
2006, 588, 472, 473, 708, 2328, 1926, 2329, 
4982, 5178, 5180
2007, 1353, 208, 1138, 1140, 7072, 4856, 6750, 
5161, 4862, 4866
2008, 75, 1266, 686, 667, 5541, 4905, 2788, 
2791, 4951, 2837
2009, 574, 93, 635, 1191, 2148, 2494, 2493, 
5059, 5058, 5084
2010, 996, 1206, 414, 415, 7926, 5496, 4284, 
4285, 5498, 1798
2011, 1177, 1291, 696, 1185, 4899, 7860, 7607, 
5212, 6425, 7919
2012, 1213, 1210, 1159, 982, 7927, 6187, 7452, 
7451, 5793, 6478
2013, 1265, 761, 762, 693, 6301, 3327, 5954, 
6300, 3403, 3606
2014, 1035, 516, 1267, 1268, 7928, 7929, 5912, 
5911, 7707, 5188
2015, 787, 1102, 432, 41, 5992, 4710, 6920, 
3130, 4709, 1821
2016, 1221, 1218, 972, 1217, 7409, 7118, 7536, 
5906, 7410, 7930
2017, 991, 992, 748, 327, 4273, 7538, 7527, 
4270, 4271, 3053
2018, 984, 1221, 972, 1217, 5910, 7536, 4233, 
5907, 5906, 7930
2019, 136, 285, 483, 922, 7358, 7931, 1946, 
3915, 5978, 7932
2020, 1328, 1308, 1333, 639, 5474, 5223, 6377, 
5476, 5478, 7933
2021, 361, 1330, 789, 1115, 7035, 7935, 3135, 
4769, 7934, 7876
2022, 1114, 1325, 438, 1326, 7685, 7695, 4768, 
5841, 5775, 5840
2023, 880, 1256, 847, 757, 6552, 6942, 3674, 
3615, 6816, 3618
2024, 1115, 1332, 1193, 789, 7874, 5434, 7936, 
7876, 7875, 7937
2025, 1183, 522, 1182, 620, 5074, 6071, 5062, 
7912, 2413, 7459
2026, 288, 482, 1252, 1172, 7546, 5254, 7013, 
6113, 5253, 5255
2027, 592, 482, 612, 1252, 2361, 2455, 2465, 
7350, 5254, 5257
2028, 606, 1220, 1225, 498, 5670, 5672, 5674, 
2384, 5965, 7151
2029, 331, 1019, 37, 752, 4371, 4336, 1666, 
3060, 6560, 3061
2030, 1161, 1162, 1219, 1225, 7332, 6528, 7938, 
5675, 6772, 7352
2031, 1302, 1303, 1089, 1301, 7853, 6360, 7854, 
7801, 6361, 6362
2032, 1226, 977, 985, 978, 7939, 4247, 7253, 
7267, 4211, 4248
2033, 1229, 419, 1230, 1232, 7940, 6538, 7184, 
7400, 7194, 7402
2034, 652, 1241, 449, 1166, 5047, 7320, 2564, 
5049, 5051, 7285
2035, 309, 122, 256, 826, 7941, 2863, 2952, 
3235, 7841, 3236
2036, 819, 866, 1171, 1165, 3526, 7071, 4907, 
6789, 7004, 6334
2037, 896, 914, 385, 888, 6982, 5872, 3767, 
3768, 5873, 3747
2038, 1224, 1161, 1220, 836, 7866, 5671, 5678, 
6795, 7312, 6794
2039, 270, 725, 705, 575, 3254, 3253, 2960, 
7865, 7242, 6289
2040, 925, 914, 915, 889, 3945, 3887, 3942, 
6260, 7440, 6314
2041, 991, 1235, 1237, 747, 5169, 4921, 5168, 
7526, 6495, 7139
2042, 1233, 1227, 1230, 1232, 7942, 6910, 6541, 
7258, 7401, 7402
2043, 331, 753, 1019, 752, 3063, 7650, 4371, 
3060, 3317, 6560
2044, 754, 1010, 1170, 1011, 7634, 7635, 7220, 
7221, 4347, 6219
2045, 691, 225, 1166, 818, 2923, 7892, 7943, 
3380, 3205, 4924
2046, 596, 505, 609, 1244, 2671, 2389, 2472, 
7671, 7714, 7944
2047, 596, 1244, 609, 1155, 7671, 7944, 2472, 
7672, 6092, 6226
2048, 1273, 341, 765, 764, 7761, 3087, 7745, 
6155, 3084, 3330
2049, 1177, 1293, 1269, 1270, 7945, 5994, 6946, 
4901, 5626, 5156
2050, 1246, 505, 1244, 609, 4937, 7714, 5811, 
4938, 2389, 7944
2051, 876, 1220, 885, 836, 6768, 7946, 3728, 
3589, 6794, 3729
2052, 1179, 1044, 1178, 1054, 7947, 7948, 4889, 
6082, 4516, 7949
2053, 1177, 850, 1271, 1269, 7920, 5014, 4902, 
6946, 5013, 5016
2054, 1274, 610, 1179, 1275, 4929, 7729, 5717, 
4930, 4928, 4891
2055, 28, 808, 809, 1361, 3552, 3373, 3245, 
6926, 5467, 7950
2056, 1246, 1244, 1155, 609, 5811, 6092, 6093, 
4938, 7944, 6226
2057, 1248, 421, 1247, 1018, 7951, 5583, 5923, 
7069, 4369, 7688
2058, 122, 309, 257, 147, 7941, 2951, 2866, 
1914, 4161, 6711
2059, 1024, 1039, 1034, 1264, 4461, 4466, 4441, 
6325, 6783, 6324
2060, 617, 1303, 1294, 1301, 7952, 7887, 6285, 
7953, 6361, 7799
2061, 406, 386, 407, 888, 7129, 5564, 1784, 
5606, 3748, 5566
2062, 406, 951, 400, 935, 7128, 7689, 3969, 
3976, 7082, 3977
2063, 1227, 879, 876, 1222, 7438, 3716, 6863, 
6864, 7059, 6866
2064, 1167, 1155, 1, 26, 7449, 6902, 6492, 
5990, 5771, 1571
2065, 1234, 1232, 1231, 1164, 7255, 7955, 7954, 
7257, 7259, 7171
2066, 402, 898, 913, 55, 7464, 6793, 3880, 
3907, 6923, 3908
2067, 1232, 990, 1234, 1231, 7956, 7957, 7255, 
7955, 7838, 7954
2068, 1233, 1227, 608, 1230, 7942, 6908, 7282, 
6541, 6910, 6907
2069, 419, 1233, 1230, 1232, 6537, 6541, 6538, 
7194, 7258, 7402
2070, 1208, 842, 886, 828, 6147, 3730, 7510, 
6186, 3525, 3738
2071, 324, 977, 744, 325, 4205, 7958, 3045, 
1658, 4206, 3044
2072, 995, 1243, 414, 996, 5042, 7722, 4282, 
4286, 7959, 4284
2073, 500, 1233, 608, 1230, 6539, 7282, 2388, 
6540, 6541, 6907
2074, 1233, 1227, 1164, 608, 7942, 7172, 6743, 
7282, 6908, 7283
2075, 1233, 419, 1000, 1232, 6537, 4297, 7960, 
7258, 7194, 7195
2076, 1167, 1240, 663, 448, 7322, 7815, 6416, 
6503, 7961, 7436
2077, 911, 918, 904, 894, 5758, 7608, 3827, 
3831, 6888, 3822
2078, 1234, 1232, 1233, 1000, 7255, 7258, 7256, 
7962, 7195, 7960
2079, 986, 1217, 984, 980, 6531, 5907, 4255, 
4242, 6534, 4234
2080, 596, 1167, 69, 448, 6504, 6491, 2351, 
2352, 6503, 1845
2081, 497, 606, 1225, 498, 2383, 5674, 7115, 
2196, 2384, 7151
2082, 163, 1228, 498, 981, 7450, 7147, 1984, 
4225, 7149, 7150
2083, 889, 896, 915, 282, 3802, 6984, 6314, 
3750, 3769, 6315
2084, 842, 886, 740, 1207, 3730, 3726, 3444, 
6150, 7963, 6828
2085, 1236, 992, 1005, 993, 7421, 4314, 7126, 
5803, 4276, 4315
2086, 72, 665, 666, 1166, 2784, 2726, 2787, 
7284, 7219, 7890
2087, 1236, 328, 992, 993, 6500, 4272, 7421, 
5803, 4274, 4276
2088, 342, 765, 766, 1045, 3086, 3331, 3089, 
4483, 7893, 7176
2089, 1245, 416, 1159, 415, 4881, 4884, 4882, 
7713, 1799, 6479
2090, 743, 1219, 976, 1214, 6248, 7468, 7463, 
6249, 6247, 7461
2091, 236, 772, 1282, 1285, 3215, 7026, 7369, 
6780, 6781, 7029
2092, 1289, 83, 571, 527, 5153, 2140, 7965, 
7964, 2543, 2620
2093, 996, 995, 1243, 994, 4286, 5042, 7959, 
4318, 4283, 6853
2094, 1360, 1359, 1358, 807, 7791, 5998, 6179, 
5845, 6282, 6180
2095, 717, 1182, 1183, 768, 5060, 5062, 5009, 
3667, 6618, 7748
2096, 1167, 750, 994, 1243, 6430, 6958, 6172, 
7448, 6959, 6853
2097, 570, 1269, 1177, 623, 6943, 6946, 6944, 
2602, 7298, 7966
2098, 674, 1285, 1288, 773, 7615, 7757, 7478, 
7490, 6669, 6663
2099, 1065, 1285, 1064, 348, 5147, 7027, 4560, 
4558, 6670, 4556
2100, 996, 1243, 1206, 1245, 7959, 7525, 7926, 
7967, 7968, 7717
2101, 1206, 1159, 415, 1245, 6189, 6479, 5498, 
7717, 4882, 7713
2102, 1296, 1297, 1301, 1298, 7629, 7355, 5359, 
7628, 7631, 7802
2103, 1191, 1196, 1205, 1325, 7275, 6004, 7969, 
7041, 6003, 5779
2104, 1353, 1138, 1144, 1140, 6750, 4870, 5162, 
5161, 4866, 4713
2105, 969, 940, 968, 948, 6283, 5183, 4111, 
4109, 5874, 4101
2106, 841, 1191, 858, 1352, 6839, 6840, 3537, 
6387, 7042, 7669
2107, 1145, 1142, 1348, 1143, 4116, 5587, 7970, 
4115, 4114, 5397
2108, 684, 1202, 248, 685, 7816, 5610, 2776, 
2779, 5592, 2777
2109, 1167, 504, 596, 1244, 6502, 2670, 6504, 
6465, 7665, 7671
2110, 1201, 221, 2, 689, 6224, 1540, 5209, 
5226, 2918, 2916
2111, 1199, 1346, 1347, 1201, 6728, 5633, 6451, 
6237, 5635, 5631
2112, 843, 842, 1243, 1155, 3524, 6818, 7446, 
7447, 6151, 6819
2113, 1227, 1165, 1164, 608, 7003, 7135, 7172, 
6908, 7971, 7283
2114, 1210, 1206, 740, 1207, 5499, 6467, 5826, 
6188, 6190, 6828
2115, 715, 716, 767, 1180, 3432, 3626, 3672, 
5402, 6685, 6686
2116, 471, 702, 472, 864, 6055, 5070, 1923, 
5955, 3509, 5930
2117, 163, 12, 499, 1230, 1469, 1986, 1985, 
7972, 7318, 7718
2118, 1235, 691, 1166, 818, 6493, 7943, 4923, 
4925, 3380, 4924
2119, 1351, 1138, 1144, 1353, 6749, 4870, 7819, 
6752, 6750, 5162
2120, 1004, 1167, 994, 1242, 6173, 6172, 4327, 
7386, 7973, 7387
2121, 1349, 1351, 1352, 1137, 7512, 7007, 6258, 
6829, 5379, 5386
2122, 1046, 1180, 766, 767, 4976, 5403, 7175, 
7974, 6686, 3332
2123, 1208, 1209, 1155, 828, 7435, 7975, 6149, 
6186, 7433, 5769
2124, 711, 753, 1249, 873, 3611, 7651, 7192, 
3571, 3609, 6166
2125, 858, 1324, 1205, 1191, 6854, 7977, 7976, 
6840, 6694, 7969
2126, 788, 1327, 799, 858, 6702, 5381, 3353, 
3490, 7668, 3491
2127, 753, 752, 851, 1249, 3317, 3469, 3468, 
7651, 6561, 7803
2128, 703, 827, 473, 127, 3399, 5179, 5875, 
7506, 7507, 1924
2129, 612, 1172, 1170, 1252, 5256, 6112, 6080, 
5257, 5255, 5539
2130, 128, 703, 1209, 473, 7978, 7979, 7472, 
1925, 5875, 7473
2131, 287, 1172, 288, 712, 7547, 6113, 1615, 
2977, 6110, 2978
2132, 508, 1250, 1016, 1170, 7457, 7643, 7280, 
6872, 7550, 7980
2133, 526, 83, 1283, 527, 2141, 7609, 5473, 
2225, 2543, 5917
2134, 1209, 262, 1155, 828, 7981, 5770, 7975, 
7433, 3243, 5769
2135, 288, 482, 916, 1252, 7546, 6081, 7012, 
7013, 5254, 7015
2136, 1219, 1221, 976, 1214, 7534, 6153, 7468, 
6247, 5908, 7461
2137, 614, 1255, 613, 510, 6184, 6632, 2491, 
2399, 5902, 2398
2138, 468, 320, 319, 158, 7917, 1652, 7847, 
1972, 4186, 4183
2139, 1168, 1249, 1248, 1021, 5926, 6381, 7982, 
5739, 5663, 6378
2140, 1224, 711, 1251, 286, 5693, 7154, 6342, 
7625, 2975, 7502
2141, 1022, 1254, 1253, 1255, 7591, 7570, 7214, 
7592, 5904, 7601
2142, 614, 638, 613, 1174, 2626, 2625, 2491, 
6631, 5344, 6634
2143, 1137, 1351, 1144, 1349, 5379, 7819, 4568, 
6829, 7512, 7667
2144, 977, 325, 978, 1226, 4206, 4208, 4211, 
7939, 7762, 7267
2145, 607, 658, 1222, 578, 2623, 7983, 7167, 
2627, 2648, 6989
2146, 225, 665, 1166, 666, 2722, 7219, 7892, 
2724, 2726, 7890
2147, 700, 93, 246, 245, 5055, 2774, 2941, 
2942, 2773, 1566
2148, 1057, 1179, 1181, 1042, 6876, 5718, 7834, 
4531, 6084, 7809
2149, 218, 564, 565, 1355, 2119, 2266, 2122, 
5410, 5165, 5407
2150, 1240, 70, 448, 503, 6039, 1846, 7961, 
5961, 2535, 2536
2151, 1073, 1069, 1075, 1282, 4591, 4599, 4612, 
7382, 6576, 5083
2152, 157, 468, 319, 158, 1971, 7847, 4181, 
1462, 1972, 4183
2153, 309, 122, 826, 148, 7941, 7841, 3235, 
4160, 2188, 6453
2154, 423, 1014, 1256, 424, 4355, 5319, 6815, 
1810, 4356, 5320
2155, 725, 299, 300, 653, 3003, 1628, 3004, 
7271, 7270, 7555
2156, 282, 889, 283, 917, 3750, 3749, 1610, 
5562, 6262, 5563
2157, 1003, 1238, 1236, 1005, 5896, 6525, 7130, 
4329, 7524, 7126
2158, 423, 1013, 1256, 1014, 4353, 7984, 6815, 
4355, 4357, 5319
2159, 482, 1172, 593, 612, 5253, 7985, 2340, 
2455, 5256, 2456
2160, 1258, 1257, 1261, 424, 5387, 7046, 6809, 
6813, 5196, 7986
2161, 753, 711, 1249, 851, 3611, 7192, 7651, 
3468, 3612, 7803
2162, 148, 122, 147, 309, 2188, 1914, 1450, 
4160, 7941, 4161
2163, 838, 247, 246, 688, 3410, 1567, 3411, 
5394, 2844, 2843
2164, 300, 476, 597, 653, 6568, 2354, 6389, 
7555, 2568, 2567
2165, 1289, 83, 675, 674, 5153, 2807, 7100, 
5154, 2804, 2750
2166, 852, 769, 1278, 1280, 3471, 5879, 7907, 
7987, 5883, 5880
2167, 852, 867, 697, 1279, 3708, 3534, 3666, 
4960, 7213, 4963
2168, 695, 820, 847, 1175, 3281, 3459, 3458, 
5986, 5987, 6826
2169, 1184, 1287, 676, 1286, 7911, 6955, 6837, 
7679, 5078, 6598
2170, 617, 530, 1301, 629, 2406, 7749, 7953, 
2480, 2433, 5360
2171, 1231, 1227, 1164, 1232, 5893, 7172, 7171, 
7955, 7401, 7259
2172, 309, 148, 826, 310, 4160, 6453, 3235, 
1640, 4164, 3288
2173, 1195, 297, 1198, 1338, 6098, 7627, 5423, 
6096, 6095, 5946
2174, 1289, 674, 675, 1282, 5154, 2750, 7100, 
7090, 7370, 6969
2175, 1199, 1201, 704, 861, 6237, 5950, 5099, 
5098, 5949, 3550
2176, 1195, 297, 1333, 296, 6098, 6099, 6100, 
7988, 1625, 6374
2177, 1195, 1198, 297, 722, 5423, 7627, 6098, 
7379, 7381, 2998
2178, 937, 1333, 1338, 297, 7269, 6097, 5763, 
6677, 6099, 6095
2179, 666, 72, 1166, 450, 2787, 7284, 7890, 
6535, 1849, 7286
2180, 298, 937, 1338, 297, 6676, 5763, 7621, 
1626, 6677, 6095
2181, 549, 1348, 550, 580, 6913, 5591, 2248, 
2302, 7093, 2292
2182, 313, 277, 106, 278, 2966, 2903, 7306, 
2965, 1604, 2906
2183, 966, 941, 968, 960, 7684, 5489, 4124, 
4117, 7656, 4131
2184, 1197, 1198, 1339, 723, 7640, 6047, 7653, 
7652, 6046, 6048
2185, 1239, 329, 750, 749, 7571, 3057, 6429, 
5806, 3054, 3314
2186, 1263, 453, 77, 514, 7741, 1858, 5528, 
6656, 2613, 2475
2187, 447, 562, 215, 23, 5574, 2112, 3594, 
1844, 2111, 1533
2188, 1232, 1227, 1163, 1231, 7401, 5892, 7989, 
7955, 5893, 5894
2189, 1362, 583, 466, 558, 6739, 2314, 5951, 
7990, 2346, 2259
2190, 1363, 1362, 466, 212, 5700, 5951, 5333, 
5093, 5724, 2260
2191, 298, 937, 956, 949, 6676, 6678, 4058, 
4039, 7554, 4064
2192, 948, 937, 297, 932, 7206, 6677, 4036, 
5233, 3987, 7466
2193, 412, 944, 388, 387, 6350, 4027, 6236, 
7991, 4026, 1738
2194, 513, 1034, 175, 514, 6321, 4435, 2014, 
2212, 6276, 2015
2195, 1177, 655, 1185, 456, 6437, 6438, 5212, 
5213, 2616, 5216
2196, 529, 655, 1292, 623, 2588, 5975, 5976, 
2418, 2666, 7992
2197, 585, 1259, 615, 455, 7549, 7290, 2630, 
2320, 5817, 2618
2198, 1275, 610, 661, 638, 4928, 2686, 6422, 
4926, 2690, 2646
2199, 1039, 1262, 1036, 1026, 6308, 6893, 4449, 
4450, 6309, 4445
2200, 729, 730, 305, 143, 3285, 3016, 3013, 
6452, 6445, 4152
2201, 702, 732, 470, 125, 3414, 6026, 6056, 
5341, 6061, 1917
2202, 1090, 1302, 1080, 1092, 5731, 7993, 4661, 
4679, 7304, 4680
2203, 846, 600, 587, 657, 6487, 2629, 7994, 
6981, 2687, 2659
2204, 1007, 1254, 509, 1170, 7030, 5536, 6874, 
6873, 5540, 5537
2205, 75, 1266, 577, 686, 5541, 7531, 2281, 
2788, 4905, 7388
2206, 1038, 1040, 1268, 1265, 4453, 5640, 5913, 
7577, 5641, 5190
2207, 769, 852, 770, 1280, 3471, 3470, 3335, 
5883, 7987, 6932
2208, 1261, 424, 1036, 1258, 7986, 4440, 6896, 
6809, 6813, 6929
2209, 775, 764, 1271, 850, 3329, 4893, 4877, 
3467, 3466, 5014
2210, 75, 452, 667, 76, 1856, 4950, 2791, 
1371, 1857, 2790
2211, 1177, 850, 821, 696, 7920, 3530, 7606, 
7607, 3544, 3232
2212, 674, 236, 773, 235, 2747, 3398, 7490, 
2746, 1556, 3406
2213, 517, 1247, 422, 616, 5982, 5584, 5885, 
2404, 5993, 7316
2214, 285, 483, 922, 286, 7931, 7932, 5978, 
1613, 7995, 7501
2215, 1293, 644, 623, 1269, 6078, 2486, 7922, 
5994, 5849, 7298
2216, 422, 1169, 506, 616, 7315, 7397, 7314, 
7316, 7032, 2405
2217, 696, 673, 1185, 1288, 7477, 5214, 7919, 
6664, 7479, 5753
2218, 1185, 674, 673, 82, 7753, 2835, 5214, 
7913, 2805, 2802
2219, 1161, 1224, 483, 286, 7866, 6181, 6549, 
7996, 7625, 7995
2220, 1177, 234, 821, 672, 7605, 3212, 7606, 
6666, 2742, 6680
2221, 1260, 615, 1176, 1257, 7902, 7903, 5357, 
7997, 7998, 5388
2222, 863, 1328, 875, 1193, 7645, 7646, 3593, 
7999, 5729, 5432
2223, 1313, 856, 1314, 1189, 6687, 6102, 5706, 
5614, 6101, 5698
2224, 1290, 1292, 1288, 1070, 5748, 5751, 5749, 
6612, 6613, 7674
2225, 387, 412, 897, 388, 7991, 5491, 3770, 
1738, 6236, 3776
2226, 285, 483, 286, 1161, 7931, 7995, 1613, 
7383, 6549, 7996
2227, 574, 461, 1315, 582, 2291, 5687, 6830, 
2301, 2300, 5283
2228, 533, 1078, 532, 191, 7845, 7863, 2231, 
2053, 4620, 2052
2229, 135, 286, 483, 593, 7499, 7995, 1945, 
2341, 7503, 2362
2230, 1344, 1347, 443, 548, 6021, 5125, 6020, 
8000, 7157, 7212
2231, 717, 648, 1188, 1299, 6250, 6115, 5263, 
5007, 6118, 6116
2232, 974, 1215, 322, 975, 5798, 5800, 4198, 
4201, 6524, 4199
2233, 625, 1307, 533, 626, 5030, 7868, 2425, 
2561, 5268, 2426
2234, 638, 592, 1276, 481, 2458, 8002, 8001, 
2457, 2338, 6593
2235, 1212, 282, 484, 599, 5709, 5559, 7698, 
5711, 5259, 2363
2236, 1328, 630, 649, 1192, 7361, 2695, 7363, 
7706, 5531, 7877
2237, 933, 940, 934, 966, 4008, 4002, 3974, 
7095, 7260, 6787
2238, 1338, 131, 477, 589, 5762, 1934, 5291, 
7886, 2333, 2332
2239, 1129, 1332, 1331, 1192, 6735, 5457, 7705, 
6736, 5437, 7427
2240, 1342, 203, 443, 1121, 7647, 4764, 7732, 
7649, 4789, 4788
2241, 1224, 483, 286, 593, 6181, 7995, 7625, 
6182, 2362, 7503
2242, 840, 109, 108, 567, 6757, 1405, 4939, 
6759, 2313, 2609
2243, 689, 269, 462, 704, 2920, 6214, 5227, 
7562, 2957, 6215
2244, 792, 1119, 365, 1118, 6901, 4780, 3140, 
6369, 4783, 4778
2245, 1018, 1247, 1248, 1169, 7688, 5923, 7069, 
8003, 6639, 7006
2246, 705, 725, 597, 575, 3253, 5327, 5328, 
6289, 7242, 2489
2247, 189, 434, 530, 17, 4616, 8004, 2048, 
1500, 1824, 2047
2248, 574, 656, 582, 1324, 2595, 2594, 2301, 
5516, 5517, 5430
2249, 1299, 579, 643, 1279, 5199, 2530, 7789, 
5198, 5202, 8005
2250, 907, 893, 908, 923, 3836, 3818, 3814, 
6588, 5761, 8006
2251, 717, 768, 1183, 769, 3667, 7748, 5009, 
3563, 3334, 5006
2252, 907, 908, 919, 923, 3814, 7348, 5886, 
6588, 8006, 3927
2253, 1050, 1183, 1278, 1051, 7141, 7103, 6424, 
4503, 5076, 5741
2254, 287, 922, 286, 891, 6243, 7501, 1614, 
3753, 8007, 3754
2255, 785, 1101, 1319, 786, 8008, 5417, 7508, 
3351, 6800, 6801
2256, 621, 1299, 579, 659, 7611, 5199, 2585, 
2634, 7540, 2631
2257, 1279, 458, 579, 572, 7173, 2285, 5202, 
7633, 2158, 2286
2258, 88, 573, 459, 679, 2145, 2157, 1874, 
2814, 8009, 5284
2259, 776, 853, 1297, 787, 3474, 7630, 5338, 
3341, 3475, 6918
2260, 1171, 819, 849, 866, 4907, 3664, 5595, 
7071, 3526, 3687
2261, 880, 1256, 1176, 847, 6552, 5391, 6553, 
3674, 6942, 8010
2262, 664, 1239, 817, 1236, 8011, 7336, 5861, 
6527, 5807, 6651
2263, 1242, 1155, 1243, 1245, 7529, 6819, 8012, 
7530, 6094, 7968
2264, 1228, 1226, 1162, 985, 7250, 6778, 6775, 
7251, 7253, 7308
2265, 911, 907, 923, 893, 3835, 6588, 5760, 
3832, 3836, 5761
2266, 1174, 756, 880, 713, 6914, 3616, 6900, 
6564, 3464, 3659
2267, 522, 182, 183, 1053, 2031, 1492, 2032, 
6073, 4508, 4507
2268, 864, 588, 707, 708, 5928, 4984, 3510, 
3507, 4982, 3264
2269, 325, 977, 744, 1226, 4206, 7958, 3044, 
7762, 7939, 6777
2270, 1351, 439, 1196, 1325, 5376, 7515, 7038, 
5378, 5377, 6003
2271, 731, 471, 878, 702, 6053, 6278, 3605, 
3433, 6055, 3604
2272, 270, 705, 99, 575, 2960, 6290, 2913, 
7865, 6289, 2153
2273, 705, 270, 99, 271, 2960, 2913, 6290, 
2959, 1597, 2914
2274, 893, 412, 908, 923, 6235, 7327, 3818, 
5761, 3917, 8006
2275, 908, 412, 919, 923, 7327, 3899, 7348, 
8006, 3917, 3927
2276, 1311, 1189, 1186, 1310, 5281, 5279, 5278, 
5615, 5616, 6716
2277, 1280, 1184, 1286, 1281, 7676, 7679, 7677, 
8013, 7773, 7827
2278, 450, 449, 1166, 652, 1851, 7285, 7286, 
2569, 2564, 5049
2279, 342, 1046, 766, 343, 4484, 7175, 3089, 
1680, 4485, 3088
2280, 1068, 188, 1292, 1293, 4574, 7569, 7244, 
5999, 8014, 7243
2281, 1076, 1288, 1066, 1074, 7673, 7759, 4602, 
4609, 7390, 4604
2282, 1069, 1284, 1282, 1073, 6574, 6575, 6576, 
4591, 7483, 7382
2283, 1184, 238, 697, 822, 8015, 2936, 4964, 
8016, 3216, 3387
2284, 237, 676, 675, 1282, 2751, 2841, 2749, 
6599, 6597, 6969
2285, 258, 145, 308, 307, 6411, 4158, 3198, 
3200, 4163, 1638
2286, 1288, 1291, 1066, 1074, 6441, 7813, 7759, 
7390, 7391, 4604
2287, 49, 912, 902, 55, 6507, 6992, 3789, 
1747, 3879, 6924
2288, 60, 952, 927, 938, 6519, 5543, 3947, 
3992, 6231, 3993
2289, 1070, 1061, 1290, 187, 4588, 5744, 6612, 
4583, 4546, 8017
2290, 288, 892, 919, 901, 3756, 7760, 8018, 
3782, 3798, 5887
2291, 287, 288, 919, 901, 1615, 8018, 8019, 
3783, 3782, 5887
2292, 746, 747, 1237, 818, 3311, 7139, 6844, 
3558, 3566, 4922
2293, 36, 1231, 745, 746, 5966, 8020, 3046, 
3049, 5968, 3310
2294, 1201, 1345, 862, 861, 6731, 6329, 5622, 
5949, 6328, 3639
2295, 451, 687, 74, 686, 7882, 2845, 1853, 
6332, 2846, 2789
2296, 1262, 1036, 1258, 1261, 6893, 6929, 6807, 
6811, 6896, 6809
2297, 556, 111, 264, 110, 2316, 2890, 7852, 
2315, 1408, 2881
2298, 38, 1013, 757, 1256, 4352, 6977, 3070, 
8021, 7984, 6816
2299, 456, 655, 1185, 571, 2616, 6438, 5216, 
2168, 2615, 7613
2300, 1264, 453, 454, 670, 7742, 1862, 8022, 
7024, 5294, 7700
2301, 863, 1328, 1193, 1205, 7645, 5729, 7999, 
8023, 5504, 7785
2302, 1237, 326, 747, 746, 6842, 3051, 7139, 
6844, 3048, 3311
2303, 1294, 717, 718, 1188, 7720, 3273, 6672, 
6607, 5263, 5264
2304, 625, 595, 1187, 479, 2562, 7345, 7347, 
2460, 2344, 7898
2305, 1296, 1294, 1299, 859, 6286, 6287, 5207, 
5203, 6671, 5204
2306, 188, 529, 1292, 1293, 2045, 5976, 7569, 
8014, 7921, 7243
2307, 263, 556, 264, 110, 7849, 7852, 1588, 
2880, 2315, 2881
2308, 1201, 1345, 1346, 862, 6731, 6730, 5635, 
5622, 6329, 6313
2309, 650, 617, 531, 1294, 2650, 2407, 2540, 
7169, 6285, 7170
2310, 1120, 1194, 1121, 1197, 6156, 8024, 4790, 
7721, 6621, 7733
2311, 970, 947, 964, 939, 4120, 4090, 4121, 
6087, 6447, 6710
2312, 859, 1294, 1298, 1296, 6671, 7800, 6022, 
5203, 6286, 7628
2313, 1247, 1223, 866, 851, 6642, 7111, 6987, 
5859, 7329, 3627
2314, 1258, 1259, 1175, 1261, 7788, 6825, 6808, 
6809, 7787, 6812
2315, 733, 7, 491, 727, 5919, 2171, 6999, 
3279, 7264, 6998
2316, 351, 1302, 1090, 776, 8025, 5731, 4657, 
3108, 5733, 5335
2317, 268, 559, 115, 267, 5315, 2164, 2889, 
1592, 6725, 2888
2318, 1022, 1014, 1173, 1012, 4382, 5219, 7217, 
4398, 4388, 7218
2319, 849, 1247, 866, 851, 5858, 6987, 3687, 
3668, 5859, 3627
2320, 874, 1306, 777, 718, 5643, 7423, 3478, 
3574, 7416, 3515
2321, 786, 1101, 1320, 360, 6800, 5414, 6802, 
3128, 4706, 7481
2322, 754, 1010, 873, 1250, 7634, 7017, 3319, 
7561, 7016, 6164
2323, 1363, 839, 811, 810, 7486, 3661, 5703, 
7162, 3439, 3374
2324, 1127, 1323, 1330, 1193, 5176, 7781, 8027, 
8026, 7782, 7784
2325, 1060, 524, 525, 184, 8028, 2223, 8029, 
4545, 2036, 2037
2326, 1047, 1180, 1046, 767, 7896, 4976, 4489, 
7897, 6686, 7974
2327, 869, 1199, 1345, 1341, 5100, 6729, 7052, 
6698, 8030, 4999
2328, 85, 1184, 677, 458, 6589, 5011, 2811, 
1870, 6591, 7174
2329, 852, 871, 1280, 1184, 3554, 7678, 7987, 
4961, 7680, 7676
2330, 1050, 430, 1278, 429, 4498, 5740, 6424, 
4497, 1818, 5878
2331, 719, 1309, 1186, 1082, 7523, 5031, 6629, 
6105, 7521, 7777
2332, 410, 918, 894, 920, 3897, 6888, 7881, 
3901, 3904, 7199
2333, 309, 308, 257, 147, 1639, 3021, 2951, 
4161, 4159, 6711
2334, 353, 1081, 352, 778, 4629, 4628, 1692, 
3112, 8031, 3113
2335, 470, 306, 732, 731, 6025, 3020, 6026, 
6054, 3017, 3286
2336, 486, 588, 281, 707, 2366, 6119, 6120, 
4985, 4984, 2968
2337, 870, 1324, 700, 883, 6855, 6693, 3686, 
3698, 7587, 3699
2338, 683, 244, 245, 825, 2770, 1565, 2771, 
5241, 3225, 3224
2339, 731, 489, 878, 471, 5548, 7328, 3605, 
6053, 2571, 6278
2340, 1264, 670, 454, 1175, 7024, 7700, 8022, 
8032, 6205, 6319
2341, 251, 116, 250, 701, 2854, 2851, 1574, 
2943, 8033, 2944
2342, 1322, 541, 1103, 198, 5323, 5322, 5326, 
5620, 2069, 4717
2343, 1248, 421, 1018, 1008, 7951, 4369, 7069, 
6412, 4338, 4374
2344, 857, 1313, 883, 1315, 6770, 5705, 3665, 
5712, 5088, 5707
2345, 871, 852, 697, 1184, 3554, 3666, 3657, 
7680, 4961, 4964
2346, 358, 784, 785, 1100, 3124, 3350, 3127, 
4702, 7053, 7619
2347, 490, 493, 1355, 565, 2273, 6806, 6850, 
2370, 2369, 5407
2348, 1294, 1187, 1306, 1305, 6604, 6606, 6608, 
7424, 7249, 5645
2349, 1313, 857, 1317, 1316, 6770, 7544, 6043, 
5001, 5713, 7337
2350, 1301, 1302, 1303, 1294, 7801, 7853, 6361, 
7799, 7798, 7887
2351, 852, 871, 770, 1280, 3554, 3553, 3470, 
7987, 7678, 6932
2352, 1071, 1286, 1280, 1062, 7826, 7677, 7856, 
4589, 8034, 7857
2353, 1182, 768, 1048, 1183, 6618, 7034, 7617, 
5062, 7748, 7142
2354, 1316, 857, 1315, 1313, 5713, 5712, 5091, 
5001, 6770, 5088
2355, 588, 864, 472, 708, 5928, 5930, 2328, 
4982, 3507, 5178
2356, 717, 1277, 291, 1188, 5061, 7842, 2987, 
5263, 6252, 8035
2357, 493, 564, 1355, 565, 2654, 5165, 6806, 
2369, 2266, 5407
2358, 1239, 329, 994, 750, 7571, 4277, 8036, 
6429, 3057, 6958
2359, 886, 1210, 1207, 1157, 7020, 6188, 7963, 
7022, 7023, 6849
2360, 490, 566, 868, 568, 2541, 5067, 5123, 
2189, 2542, 6253
2361, 1104, 539, 538, 1321, 6353, 2237, 7778, 
7415, 6366, 7831
2362, 35, 1243, 751, 740, 5041, 5988, 3058, 
3037, 6827, 3303
2363, 1172, 482, 593, 1251, 5253, 2340, 7985, 
6857, 6550, 7325
2364, 692, 876, 866, 1227, 3643, 3598, 3527, 
7001, 6863, 6865
2365, 284, 1160, 917, 285, 6185, 7360, 6124, 
1612, 6505, 5980
2366, 1109, 1320, 1295, 1322, 5036, 5037, 5038, 
6264, 6263, 5325
2367, 116, 467, 576, 1354, 1902, 2254, 2323, 
8037, 5443, 7075
2368, 540, 1321, 1105, 1322, 8038, 8040, 8039, 
5619, 6690, 7495
2369, 1234, 1164, 1166, 1233, 7257, 6742, 7804, 
7256, 6743, 5052
2370, 1315, 92, 245, 683, 5686, 2850, 5238, 
5239, 2822, 2771
2371, 940, 933, 941, 966, 4008, 4012, 4011, 
7260, 7095, 7684
2372, 1105, 540, 197, 539, 8039, 2067, 4726, 
6339, 2238, 2066
2373, 1199, 869, 1337, 1341, 5100, 6699, 7097, 
8030, 6698, 6700
2374, 1040, 1038, 1030, 1265, 4453, 4459, 4469, 
5641, 7577, 6140
2375, 1354, 467, 576, 22, 5443, 2254, 7075, 
5460, 2116, 2255
2376, 540, 1321, 539, 1105, 8038, 6366, 2238, 
8039, 8040, 6339
2377, 759, 1037, 1027, 336, 6488, 4446, 6512, 
3075, 4442, 4411
2378, 1322, 680, 573, 1321, 7152, 5103, 6223, 
6690, 5104, 5102
2379, 1124, 1196, 439, 1323, 5019, 7515, 4798, 
5021, 5023, 7687
2380, 1335, 1195, 631, 1192, 8041, 5426, 5512, 
5533, 7426, 7880
2381, 340, 339, 762, 1265, 1676, 3081, 3080, 
6139, 6138, 5954
2382, 594, 834, 730, 488, 8042, 3283, 7109, 
2342, 6658, 6444
2383, 878, 846, 864, 587, 3733, 3536, 3681, 
8043, 7994, 5929
2384, 288, 287, 919, 916, 1615, 8019, 8018, 
7012, 6244, 3900
2385, 287, 922, 919, 916, 6243, 3932, 8019, 
6244, 3914, 3900
2386, 1137, 1327, 1325, 1352, 5382, 5777, 5380, 
5386, 5383, 7008
2387, 1127, 1114, 1125, 1330, 4808, 4825, 4822, 
8027, 6557, 6559
2388, 1199, 1343, 1345, 1341, 6399, 7663, 6729, 
8030, 6160, 4999
2389, 508, 171, 509, 1007, 2004, 2005, 2207, 
6871, 4334, 6874
2390, 834, 489, 594, 878, 5546, 2343, 8042, 
3709, 7328, 7432
2391, 720, 845, 856, 1189, 3454, 3588, 3587, 
6683, 6103, 6101
2392, 600, 707, 29, 726, 4986, 2967, 6089, 
6388, 3278, 3006
2393, 936, 398, 395, 396, 6996, 3853, 3950, 
3951, 3852, 1764
2394, 1352, 798, 370, 799, 6256, 3152, 6257, 
5385, 3364, 3155
2395, 1156, 495, 1213, 602, 5306, 5309, 5307, 
7532, 2376, 7442
2396, 439, 1351, 1144, 1137, 5376, 7819, 4569, 
4570, 5379, 4568
2397, 676, 237, 822, 1286, 2751, 3217, 7604, 
6598, 6600, 5107
2398, 1261, 1264, 454, 1175, 6897, 8022, 6833, 
6812, 8032, 6319
2399, 595, 1309, 532, 625, 7344, 7835, 2423, 
2562, 5028, 2424
2400, 594, 581, 464, 831, 2500, 2295, 2501, 
7011, 7010, 4965
2401, 1087, 1094, 1304, 1092, 4683, 7188, 7190, 
4681, 4686, 7598
2402, 292, 133, 293, 1188, 5247, 5248, 1621, 
5265, 7844, 8044
2403, 1301, 1297, 1295, 433, 7355, 6919, 5361, 
7357, 7356, 7444
2404, 293, 930, 294, 932, 5250, 5756, 1622, 
8045, 4014, 7840
2405, 1308, 1187, 294, 932, 5145, 5143, 5144, 
5225, 6170, 7840
2406, 788, 863, 789, 1330, 3503, 3502, 3354, 
7036, 8046, 7935
2407, 1081, 1305, 352, 778, 4916, 4917, 4628, 
8031, 5767, 3113
2408, 731, 489, 471, 470, 5548, 2571, 6053, 
6054, 2185, 1920
2409, 489, 878, 657, 594, 7328, 7431, 2611, 
2343, 7432, 2642
2410, 754, 1250, 873, 712, 7561, 6164, 3319, 
3607, 6766, 3600
2411, 1349, 1136, 1137, 370, 7374, 4852, 6829, 
6259, 4847, 4849
2412, 905, 925, 926, 910, 6836, 3946, 4896, 
3829, 6585, 6271
2413, 1198, 660, 632, 647, 5944, 2705, 5112, 
5422, 2638, 2600
2414, 1338, 654, 477, 299, 6174, 2573, 5291, 
6135, 6176, 6137
2415, 632, 633, 660, 1336, 2554, 2706, 2705, 
8047, 7563, 5947
2416, 1338, 299, 298, 1336, 6135, 1627, 7621, 
5948, 6177, 7622
2417, 299, 1336, 724, 298, 6177, 6889, 3002, 
1627, 7622, 3001
2418, 494, 1246, 505, 11, 4936, 4937, 2204, 
1975, 7904, 1998
2419, 665, 449, 1241, 1166, 8048, 7320, 7119, 
7219, 7285, 5051
2420, 1002, 1167, 999, 1240, 6171, 6464, 4305, 
7323, 7322, 6064
2421, 1354, 801, 576, 250, 6652, 7247, 7075, 
7923, 3230, 7248
2422, 1328, 639, 649, 624, 5476, 2546, 7363, 
7362, 2689, 2694
2423, 1242, 996, 1243, 994, 7385, 7959, 8012, 
7387, 4318, 6853
2424, 836, 286, 1224, 1161, 3392, 7625, 6795, 
7312, 7996, 7866
2425, 634, 1344, 1199, 1337, 6401, 6396, 7814, 
6402, 6404, 7097
2426, 1217, 1214, 1160, 1215, 5905, 6196, 7413, 
6413, 6197, 6191
2427, 1293, 529, 1292, 623, 7921, 5976, 7243, 
7922, 2418, 7992
2428, 702, 827, 472, 864, 3287, 5069, 5070, 
3509, 3508, 5930
2429, 656, 1328, 624, 639, 5505, 7362, 2674, 
2688, 5476, 2689
2430, 632, 1197, 1336, 1198, 7641, 7861, 8047, 
5112, 7640, 5945
2431, 996, 1243, 414, 1206, 7959, 7722, 4284, 
7926, 7525, 5496
2432, 824, 680, 1319, 242, 8049, 7153, 7064, 
3220, 2762, 6036
2433, 474, 262, 1155, 1209, 6497, 5770, 6903, 
7925, 7981, 7975
2434, 596, 504, 505, 1244, 2670, 2203, 2671, 
7671, 7665, 7714
2435, 418, 1231, 417, 990, 7751, 7750, 1802, 
4267, 7838, 4268
2436, 664, 1239, 663, 223, 8011, 6417, 2829, 
2719, 6443, 2718
2437, 999, 1002, 1240, 989, 4305, 7323, 6064, 
4302, 4306, 5962
2438, 501, 500, 1233, 652, 2199, 6539, 7715, 
2563, 2565, 5048
2439, 1229, 978, 985, 418, 7265, 4248, 7254, 
7888, 4214, 4237
2440, 1123, 1342, 546, 1197, 7648, 7429, 7660, 
7659, 6620, 7430
2441, 1305, 1081, 1082, 778, 4916, 4633, 6106, 
5767, 8031, 5766
2442, 625, 1307, 532, 533, 5030, 7836, 2424, 
2425, 7868, 2231
2443, 1197, 1336, 723, 860, 7861, 7624, 7652, 
7096, 7696, 3520
2444, 1040, 1035, 1268, 1033, 4452, 5911, 5640, 
4451, 4438, 7122
2445, 963, 928, 943, 961, 5772, 5690, 4112, 
4128, 5689, 4130
2446, 13, 506, 422, 169, 1999, 7314, 1808, 
1476, 2000, 4330
2447, 1303, 1077, 1092, 1089, 6357, 4676, 7595, 
6360, 4670, 4664
2448, 1168, 1018, 1248, 1169, 7470, 7069, 7982, 
7639, 8003, 7006
2449, 1028, 1039, 1263, 1041, 4470, 6785, 7025, 
4456, 4471, 6482
2450, 632, 545, 546, 1340, 2438, 2244, 2439, 
5111, 5836, 7658
2451, 1256, 1013, 423, 38, 7984, 4353, 6815, 
8021, 4352, 1809
2452, 27, 560, 4, 268, 6717, 2166, 1572, 
1593, 5316, 2878
2453, 665, 691, 1166, 1235, 8050, 7943, 7219, 
7120, 6493, 4923
2454, 1123, 203, 546, 1342, 4794, 2080, 7660, 
7648, 7647, 7429
2455, 578, 641, 1165, 451, 2476, 7702, 7701, 
2283, 2473, 6333
2456, 604, 1156, 646, 602, 5345, 6868, 2517, 
2515, 7532, 2516
2457, 745, 417, 1163, 1231, 7299, 7200, 7300, 
8020, 7750, 5894
2458, 1191, 1196, 636, 1205, 7275, 6661, 7276, 
7969, 6004, 6648
2459, 1356, 739, 802, 816, 6291, 3535, 5788, 
8051, 3233, 3517
2460, 493, 9, 490, 1355, 1974, 1965, 2273, 
6806, 7114, 6850
2461, 1331, 1126, 1198, 1339, 8052, 5480, 7380, 
8053, 7873, 6047
2462, 814, 27, 1204, 800, 3252, 5666, 5297, 
3378, 3421, 5649
2463, 1054, 1179, 1272, 1178, 6082, 4892, 6083, 
7949, 4889, 4888
2464, 804, 1357, 734, 1355, 5363, 6852, 3412, 
5364, 5365, 6851
2465, 814, 445, 382, 45, 5295, 2372, 3188, 
3189, 1839, 1729
2466, 813, 1154, 382, 814, 7509, 2374, 3187, 
3377, 5637, 3188
2467, 1185, 674, 1288, 673, 7753, 7478, 5753, 
5214, 2835, 7479
2468, 1307, 533, 1078, 532, 7868, 7845, 5439, 
7836, 2231, 7863
2469, 532, 1309, 1078, 1307, 7835, 6994, 7863, 
7836, 5032, 5439
2470, 119, 254, 120, 155, 2860, 2859, 1418, 
1909, 6970, 1910
2471, 1118, 1117, 1339, 1126, 4779, 5245, 5246, 
4817, 4816, 7873
2472, 837, 1259, 695, 847, 6960, 5131, 3405, 
3586, 6824, 3458
2473, 431, 524, 523, 1281, 5054, 2222, 5053, 
5486, 8054, 5487
2474, 1186, 719, 1312, 855, 6629, 7224, 7343, 
6841, 3506, 6581
2475, 720, 1310, 855, 1186, 6714, 6578, 3597, 
5174, 6716, 6841
2476, 1063, 772, 347, 1064, 6933, 3101, 4554, 
4557, 6936, 4555
2477, 1312, 779, 855, 719, 7225, 3483, 6581, 
7224, 3480, 3506
2478, 390, 918, 410, 411, 7101, 3897, 5519, 
5520, 3896, 1789
2479, 1142, 1134, 1135, 1202, 4125, 4845, 4139, 
5589, 5586, 6076
2480, 460, 90, 91, 682, 1875, 1386, 1876, 
5934, 2821, 2820
2481, 1352, 1203, 1191, 1351, 7511, 5085, 7042, 
7007, 7159, 7040
2482, 1295, 1190, 541, 1322, 7228, 7839, 5321, 
5325, 5289, 5323
2483, 772, 1064, 1285, 348, 6936, 7027, 6781, 
3100, 4556, 6670
2484, 344, 768, 345, 1048, 3093, 3092, 1682, 
4490, 7034, 4491
2485, 1300, 1279, 572, 678, 8055, 7633, 7227, 
8056, 8057, 8058
2486, 1032, 1171, 763, 1247, 7723, 8059, 6239, 
7000, 5984, 6790
2487, 717, 1277, 716, 291, 5061, 6662, 3272, 
2987, 7842, 2986
2488, 1050, 769, 1278, 1183, 7140, 5879, 6424, 
7141, 5006, 7103
2489, 1296, 643, 1279, 1299, 5095, 8005, 8060, 
5207, 7789, 5198
2490, 595, 1309, 1304, 532, 7344, 7191, 7178, 
2423, 7835, 7808
2491, 21, 560, 554, 1204, 2107, 2253, 2096, 
7165, 5300, 7166
2492, 1307, 192, 1078, 533, 5438, 4619, 5439, 
7868, 2054, 7845
2493, 1117, 1116, 1331, 1129, 4776, 8061, 7516, 
4815, 4814, 7705
2494, 1092, 1080, 1305, 1302, 4680, 4915, 7420, 
7304, 7993, 7883
2495, 590, 1187, 1308, 132, 8062, 5145, 7033, 
2335, 6169, 5224
2496, 784, 681, 1319, 1108, 6033, 6034, 6035, 
7054, 7088, 7056
2497, 89, 90, 538, 681, 1385, 2290, 2289, 
2819, 2818, 7305
2498, 1349, 1353, 1144, 1146, 7818, 5162, 7667, 
7666, 5160, 4135
2499, 1054, 1178, 1272, 428, 7949, 4888, 6083, 
4510, 5630, 6009
2500, 562, 1359, 561, 1360, 5575, 6756, 2113, 
6129, 7791, 6804
2501, 1027, 760, 759, 337, 6511, 3325, 6512, 
4412, 3077, 3074
2502, 268, 4, 115, 560, 2878, 1413, 2889, 
5316, 2166, 2165
2503, 1353, 1349, 1351, 1203, 7818, 7512, 6752, 
7161, 6755, 7159
2504, 1314, 582, 1315, 627, 5427, 5283, 5428, 
5754, 2591, 5243
2505, 805, 376, 806, 1358, 3170, 3171, 3370, 
4910, 4918, 7585
2506, 1317, 42, 781, 435, 6562, 3118, 6041, 
6042, 1825, 6044
2507, 1183, 1277, 620, 1182, 5064, 5956, 7912, 
5062, 5063, 7459
2508, 863, 1330, 1193, 789, 8046, 7784, 7999, 
3502, 7935, 7937
2509, 222, 223, 663, 690, 1543, 2718, 2717, 
2922, 2921, 6418
2510, 648, 1277, 620, 1183, 6251, 5956, 2639, 
7233, 5064, 7912
2511, 1340, 1113, 1126, 1335, 5837, 4806, 5482, 
5109, 7767, 5481
2512, 1264, 1263, 1034, 514, 6784, 6657, 6324, 
7735, 6656, 6276
2513, 1237, 990, 1231, 1234, 8063, 7838, 7296, 
7709, 7957, 7954
2514, 806, 805, 1358, 840, 3370, 4910, 7585, 
3556, 3641, 6758
2515, 1197, 1126, 1128, 1118, 7872, 4811, 7734, 
6367, 4817, 4827
2516, 1229, 1227, 1163, 1232, 7207, 5892, 7266, 
7400, 7401, 7989
2517, 325, 978, 745, 36, 4208, 7301, 3047, 
1659, 4209, 3046
2518, 1167, 843, 1155, 26, 5991, 7447, 7449, 
5990, 3504, 5771
2519, 848, 746, 745, 1231, 3460, 3310, 3461, 
5891, 5968, 8020
2520, 1363, 1362, 829, 466, 5700, 5171, 5334, 
5333, 5951, 5332
2521, 1195, 1198, 1331, 1335, 5423, 7380, 7378, 
8041, 5110, 7704
2522, 796, 1202, 1134, 1348, 5612, 5586, 7504, 
5572, 5588, 5585
2523, 1353, 208, 553, 1138, 7072, 2093, 6754, 
6750, 4856, 6751
2524, 1124, 439, 1114, 1323, 4798, 4767, 4803, 
5021, 7687, 7686
2525, 1306, 718, 1294, 777, 7416, 6672, 6608, 
7423, 3515, 6673
2526, 462, 704, 598, 1337, 6215, 5868, 2355, 
7376, 6602, 6603
2527, 719, 1309, 1187, 1186, 7523, 7346, 6475, 
6629, 5031, 5141
2528, 61, 959, 62, 404, 4065, 5375, 1754, 
1777, 4066, 3861
2529, 1200, 1345, 1343, 1132, 6949, 7663, 6400, 
7210, 7211, 8064
2530, 704, 724, 1337, 869, 3718, 6601, 6602, 
3560, 3688, 6699
2531, 1182, 522, 521, 620, 6071, 2220, 4975, 
7459, 2413, 2412
2532, 634, 1344, 548, 1199, 6401, 8000, 2443, 
7814, 6396, 7377
2533, 119, 155, 156, 254, 1909, 1460, 2319, 
2860, 6970, 7079
2534, 648, 1277, 480, 620, 6251, 5138, 2527, 
2639, 5956, 2640
2535, 1161, 884, 1219, 1162, 7313, 6529, 7938, 
7332, 6517, 6528
2536, 930, 133, 932, 293, 3981, 4001, 4014, 
5250, 5248, 8045
2537, 595, 1309, 1187, 1304, 7344, 7346, 7345, 
7178, 7191, 7885
2538, 611, 1168, 1172, 1251, 7573, 6860, 7837, 
7572, 6858, 6857
2539, 288, 289, 916, 919, 1616, 4935, 7012, 
8018, 5863, 3900
2540, 1160, 710, 284, 844, 6255, 2973, 6185, 
5305, 3453, 3452
2541, 737, 736, 601, 153, 3293, 6406, 6395, 
6407, 6508, 2191
2542, 299, 654, 476, 653, 6176, 2572, 6569, 
7270, 2608, 2568
2543, 654, 724, 653, 299, 6796, 6797, 2608, 
6176, 3002, 7270
2544, 720, 1310, 856, 855, 6714, 6715, 3587, 
3597, 6578, 3596
2545, 1199, 1347, 1200, 1344, 6451, 6018, 6398, 
6396, 6021, 6019
2546, 75, 1266, 452, 577, 5541, 4952, 1856, 
2281, 7531, 2284
2547, 1047, 768, 344, 1048, 8065, 3093, 4488, 
4492, 7034, 4490
2548, 387, 412, 413, 897, 7991, 1791, 4941, 
3770, 5491, 4946
2549, 929, 412, 930, 965, 3957, 3959, 3961, 
5135, 7043, 7108
2550, 944, 412, 388, 945, 6350, 6236, 4027, 
4050, 7044, 4029
2551, 27, 801, 250, 4, 3231, 3230, 1573, 
1572, 5664, 2852
2552, 1267, 667, 76, 668, 4947, 2790, 6727, 
4953, 2731, 2793
2553, 1308, 1333, 639, 478, 5223, 7933, 5478, 
5446, 5419, 2463
2554, 1199, 1346, 1200, 1347, 6728, 6950, 6398, 
6451, 5633, 6018
2555, 1105, 540, 198, 197, 8039, 2068, 4725, 
4726, 2067, 1510
2556, 958, 409, 300, 934, 6763, 6161, 4063, 
6762, 3972, 7302
2557, 486, 475, 29, 409, 2179, 6385, 6090, 
6821, 8066, 5367
2558, 474, 1208, 1155, 609, 8067, 6149, 6903, 
2462, 6227, 6226
2559, 497, 498, 1225, 162, 2196, 7151, 7115, 
1982, 1983, 6457
2560, 1340, 632, 1197, 546, 5111, 7641, 7642, 
7658, 2439, 7430
2561, 1260, 644, 585, 661, 5846, 2708, 7579, 
6611, 2685, 2661
2562, 630, 1335, 631, 1192, 5529, 5512, 2581, 
5531, 5533, 7880
2563, 497, 972, 162, 1225, 7116, 4190, 1982, 
7115, 6455, 6457
2564, 145, 732, 124, 470, 6027, 6060, 2183, 
1961, 6026, 1916
2565, 792, 1119, 793, 365, 6901, 7098, 3358, 
3140, 4780, 3143
2566, 991, 747, 326, 327, 7526, 3051, 4269, 
4270, 3050, 1661
2567, 988, 501, 165, 164, 8068, 1990, 4260, 
4261, 1989, 1471
2568, 1252, 638, 1174, 613, 7349, 5344, 7552, 
7351, 2625, 6634
2569, 910, 925, 906, 905, 6585, 8069, 3840, 
3829, 6836, 3838
2570, 1012, 1253, 334, 756, 7215, 7588, 4348, 
4874, 6964, 3069
2571, 703, 709, 1209, 473, 3429, 7453, 7979, 
5875, 5581, 7473
2572, 1356, 493, 1355, 739, 6805, 6806, 5119, 
6291, 7871, 8070
2573, 442, 1194, 1121, 1120, 7737, 8024, 4787, 
4785, 6156, 4790
2574, 1260, 837, 1269, 1275, 5354, 5943, 5847, 
5848, 5942, 5851
2575, 1221, 1161, 1214, 1219, 7417, 7418, 5908, 
7534, 7938, 6247
2576, 442, 1121, 1344, 443, 4787, 7731, 6747, 
1835, 4788, 6020
2577, 625, 1309, 1186, 1187, 5028, 5031, 5029, 
7347, 7346, 5141
2578, 703, 709, 828, 1209, 3429, 3443, 3390, 
7979, 7453, 7433
2579, 1219, 977, 976, 987, 7445, 4207, 7468, 
7353, 4245, 4246
2580, 1212, 282, 283, 484, 5709, 1610, 8071, 
7698, 5559, 5561
2581, 262, 703, 128, 261, 2955, 7978, 2874, 
1585, 2956, 2871
2582, 606, 497, 1225, 1218, 2383, 7115, 5674, 
7454, 6545, 7117
2583, 1237, 1166, 1164, 818, 4920, 6742, 7295, 
4922, 4924, 7132
2584, 1293, 188, 15, 428, 8014, 1499, 8072, 
5628, 4548, 1816
2585, 1161, 1160, 1214, 710, 6548, 6196, 7418, 
7311, 6255, 6246
2586, 1219, 1161, 1214, 710, 7938, 7418, 6247, 
6245, 7311, 6246
2587, 419, 12, 163, 1230, 1804, 1469, 4192, 
6538, 7318, 7972
2588, 1258, 1259, 1176, 847, 7788, 6961, 5390, 
6940, 6824, 8010
2589, 1232, 990, 1000, 1234, 7956, 4303, 7195, 
7255, 7957, 7962
2590, 1226, 879, 745, 1163, 7057, 3613, 7330, 
7060, 7058, 7300
2591, 1164, 666, 450, 1165, 7712, 6535, 7574, 
7135, 7292, 7384
2592, 232, 1175, 670, 820, 5985, 6205, 2736, 
3210, 5987, 6496
2593, 1229, 419, 979, 1230, 7940, 4216, 7185, 
7184, 6538, 7183
2594, 1081, 353, 1082, 778, 4629, 4631, 4633, 
8031, 3112, 5766
2595, 1164, 666, 1166, 450, 7712, 7890, 6742, 
7574, 6535, 7286
2596, 225, 665, 224, 691, 2722, 2721, 1545, 
2923, 8050, 2924
2597, 1240, 70, 663, 448, 6039, 2780, 7815, 
7961, 1846, 7436
2598, 449, 665, 72, 1166, 8048, 2784, 1848, 
7285, 7219, 7284
2599, 1264, 512, 1024, 1261, 8073, 8074, 6325, 
6897, 6832, 7727
2600, 974, 321, 322, 741, 4197, 1655, 4198, 
5801, 3039, 3038
2601, 1163, 848, 745, 1231, 5890, 3461, 7300, 
5894, 5891, 8020
2602, 1019, 420, 37, 752, 4337, 1805, 4336, 
6560, 6974, 3061
2603, 984, 1221, 1214, 976, 5910, 5908, 5909, 
4244, 6153, 7461
2604, 863, 875, 789, 1193, 3593, 3697, 3502, 
7999, 5432, 7937
2605, 1239, 664, 817, 223, 8011, 5861, 7336, 
6443, 2719, 3203
2606, 1239, 749, 817, 1236, 5806, 3739, 7336, 
5807, 5805, 6651
2607, 1021, 1168, 1250, 1016, 5739, 5927, 5660, 
4395, 5738, 7643
2608, 578, 450, 1165, 608, 2282, 7384, 7701, 
2520, 2519, 7971
2609, 318, 156, 253, 319, 4185, 6058, 2948, 
1651, 4182, 2945
2610, 450, 1164, 1165, 608, 7574, 7135, 7384, 
2519, 7283, 7971
2611, 1253, 1011, 334, 755, 6222, 4346, 7588, 
6220, 6221, 3066
2612, 1250, 1009, 1021, 1010, 5659, 4394, 5660, 
7016, 4344, 4399
2613, 753, 1019, 752, 1249, 7650, 6560, 3317, 
7651, 6380, 6561
2614, 815, 826, 256, 469, 3237, 3236, 3234, 
6461, 6463, 6823
2615, 1247, 662, 641, 578, 6641, 2693, 5983, 
6988, 2709, 2476
2616, 1247, 662, 1222, 1223, 6641, 8075, 6990, 
6642, 6640, 7110
2617, 1006, 1168, 1016, 507, 5737, 5738, 4370, 
7398, 7279, 7281
2618, 295, 1328, 721, 1189, 6375, 6861, 2995, 
6681, 5475, 8076
2619, 1061, 1076, 1284, 1073, 4607, 7568, 5747, 
4590, 4608, 7483
2620, 121, 815, 255, 256, 6822, 3190, 2861, 
2864, 3234, 1579
2621, 226, 687, 1165, 692, 2832, 7291, 7136, 
2926, 7900, 7002
2622, 509, 1254, 510, 613, 5536, 5903, 2208, 
2397, 6644, 2398
2623, 1253, 1022, 1012, 1020, 7214, 4398, 7215, 
7575, 4390, 4387
2624, 509, 508, 1170, 612, 2207, 6872, 5537, 
2396, 2395, 6080
2625, 507, 1006, 170, 1016, 7398, 4331, 2002, 
7281, 4370, 4364
2626, 1227, 879, 1222, 1163, 7438, 7059, 6864, 
5892, 7058, 7062
2627, 618, 610, 1274, 638, 2498, 4929, 5716, 
2557, 2690, 4927
2628, 420, 37, 763, 1031, 1805, 3082, 6856, 
4424, 4423, 6240
2629, 519, 518, 179, 1272, 2217, 2024, 2025, 
7728, 6069, 7594
2630, 1260, 661, 585, 614, 6611, 2661, 7579, 
8077, 2647, 2656
2631, 185, 1287, 525, 1060, 8078, 8079, 2038, 
4544, 6307, 8029
2632, 1290, 1076, 1288, 1284, 7567, 7673, 5749, 
5743, 7568, 7832
2633, 1178, 1273, 1275, 1269, 8080, 6275, 4887, 
5158, 5017, 5851
2634, 332, 1010, 754, 333, 4342, 7634, 3065, 
1668, 4343, 3064
2635, 570, 672, 80, 81, 7460, 2801, 2137, 
2138, 2800, 1376
2636, 674, 1289, 1285, 1282, 5154, 7915, 7615, 
7370, 7090, 7029
2637, 1252, 638, 1274, 1174, 7349, 4927, 7551, 
7552, 5344, 5343
2638, 1017, 510, 173, 172, 5899, 2008, 4365, 
4366, 2007, 1480
2639, 1247, 1033, 421, 1032, 5582, 4429, 5583, 
7000, 4432, 4427
2640, 692, 876, 1227, 848, 3643, 6863, 7001, 
3573, 3673, 5889
2641, 1226, 885, 744, 879, 6776, 3691, 6777, 
7057, 3694, 3614
2642, 1190, 1320, 679, 1322, 8081, 7889, 5286, 
5289, 6263, 5285
2643, 668, 1038, 1041, 1025, 5652, 4462, 6483, 
5650, 4448, 4463
2644, 1039, 1024, 1036, 1264, 4461, 4455, 4449, 
6783, 6325, 6895
2645, 577, 1171, 451, 686, 5658, 6335, 2280, 
7388, 4908, 6332
2646, 1247, 1268, 1033, 1032, 6555, 7122, 5582, 
7000, 5638, 4432
2647, 339, 1265, 761, 762, 6138, 6301, 3078, 
3081, 5954, 3327
2648, 687, 819, 227, 686, 7899, 3207, 2833, 
2846, 4895, 2838
2649, 607, 1228, 499, 1230, 7146, 8082, 2386, 
6909, 7180, 7718
2650, 1257, 425, 424, 1015, 7049, 1811, 5196, 
5194, 4359, 4358
2651, 610, 1272, 1179, 1275, 7730, 4892, 7729, 
4928, 4890, 4891
2652, 783, 1098, 1107, 1318, 5549, 4738, 5550, 
4991, 6953, 6365
2653, 1259, 80, 672, 671, 5816, 2801, 6679, 
5130, 2798, 2743
2654, 1185, 82, 571, 1289, 7913, 2139, 7613, 
7754, 5152, 7965
2655, 850, 1177, 821, 1269, 7920, 7606, 3530, 
5013, 6946, 7548
2656, 1175, 79, 454, 455, 6203, 1861, 6319, 
6320, 1863, 1865
2657, 1038, 1029, 668, 1041, 4458, 6481, 5652, 
4462, 4457, 6483
2658, 527, 187, 528, 1290, 2042, 2043, 2226, 
5916, 8017, 6439
2659, 1055, 39, 1271, 426, 4478, 4894, 7765, 
4479, 1813, 7824
2660, 1271, 427, 1044, 426, 7908, 4480, 7763, 
7824, 1814, 4481
2661, 1177, 456, 570, 623, 5213, 2276, 6944, 
7966, 2603, 2602
2662, 1229, 1227, 1222, 1163, 7207, 6864, 7208, 
7266, 5892, 7062
2663, 1233, 1227, 1232, 1164, 7942, 7401, 7258, 
6743, 7172, 7259
2664, 622, 1281, 457, 1184, 7772, 8083, 2657, 
7263, 7773, 6590
2665, 1276, 520, 1180, 1181, 7578, 7895, 5513, 
5514, 5151, 4978
2666, 1259, 233, 671, 672, 5129, 2739, 5130, 
6679, 2741, 2743
2667, 1017, 510, 1255, 173, 5899, 5902, 5900, 
4365, 2008, 7738
2668, 677, 238, 239, 697, 2753, 1559, 2754, 
5012, 2936, 2935
2669, 1290, 1283, 1289, 527, 5742, 7089, 8084, 
5916, 5917, 7964
2670, 761, 229, 668, 230, 3209, 2729, 6584, 
3208, 1550, 2730
2671, 1051, 1058, 1183, 1053, 4522, 8085, 5076, 
4509, 4523, 6556
2672, 1289, 1288, 1284, 1290, 7755, 7832, 7091, 
8084, 5749, 5743
2673, 1288, 1289, 1285, 674, 7755, 7915, 7757, 
7478, 5154, 7615
2674, 772, 1064, 1286, 1282, 6936, 6937, 6935, 
7026, 7028, 5080
2675, 1270, 1068, 427, 1074, 6000, 4572, 7909, 
7914, 4592, 4594
2676, 1274, 854, 1275, 1179, 5568, 5570, 4930, 
5717, 6272, 4891
2677, 1337, 1197, 1336, 633, 6623, 7861, 6891, 
6738, 6737, 7563
2678, 133, 1277, 291, 413, 6884, 7842, 8086, 
3962, 7394, 4940
2679, 1240, 1002, 1239, 1005, 7323, 7324, 7124, 
7125, 4320, 7127
2680, 1277, 648, 591, 1188, 6251, 2526, 7683, 
6252, 6115, 7582
2681, 567, 566, 1358, 220, 2268, 4911, 6122, 
2126, 2123, 5368
2682, 525, 1281, 1060, 1287, 8087, 6304, 8029, 
8079, 7825, 6307
2683, 673, 696, 235, 1288, 7477, 2933, 2745, 
7479, 6664, 7480
2684, 1060, 524, 1281, 525, 8028, 8054, 6304, 
8029, 2223, 8087
2685, 89, 573, 88, 680, 2146, 2145, 1384, 
2816, 5103, 2817
2686, 823, 867, 1300, 1279, 3533, 7558, 7559, 
6348, 7213, 8055
2687, 1296, 867, 1300, 853, 5205, 7558, 5347, 
5217, 3651, 7560
2688, 1299, 579, 659, 643, 5199, 2631, 7540, 
7789, 2530, 2632
2689, 1294, 717, 859, 718, 7720, 3528, 6671, 
6672, 3273, 3514
2690, 1306, 718, 293, 1188, 7416, 2990, 6917, 
6609, 5264, 8044
2691, 237, 236, 1282, 675, 1557, 7369, 6599, 
2749, 2748, 6969
2692, 524, 457, 1281, 525, 2696, 8083, 8054, 
2223, 2699, 8087
2693, 1077, 1092, 1087, 1304, 4676, 4681, 4656, 
7828, 7598, 7190
2694, 1239, 1002, 994, 993, 7324, 4317, 8036, 
5804, 4316, 4279
2695, 87, 86, 678, 572, 1382, 2813, 2812, 
2144, 2143, 8058
2696, 1167, 1239, 994, 750, 6419, 8036, 6172, 
6430, 6429, 6958
2697, 1189, 656, 651, 639, 5699, 2707, 6674, 
5479, 2688, 2712
2698, 1312, 1186, 1091, 1082, 7343, 8088, 7626, 
7223, 7777, 4673
2699, 1309, 1091, 1094, 1078, 6993, 4677, 7187, 
6994, 4663, 4678
2700, 936, 410, 942, 396, 3982, 6132, 6997, 
3951, 3953, 8089
2701, 750, 1167, 843, 1243, 6430, 5991, 3676, 
6959, 7448, 7446
2702, 1321, 89, 539, 538, 5101, 2299, 6366, 
7831, 2289, 2237
2703, 1277, 6, 480, 481, 6883, 1940, 5138, 
5137, 1941, 2175
2704, 1306, 1187, 1188, 293, 6606, 6605, 6609, 
6917, 6474, 8044
2705, 1206, 1243, 1207, 1245, 7525, 6820, 6190, 
7717, 7968, 7437
2706, 1242, 997, 1244, 1245, 8090, 5812, 7528, 
7530, 7439, 6091
2707, 1318, 1110, 1104, 1108, 7222, 4742, 7780, 
7843, 4755, 4734
2708, 1207, 1243, 1155, 1245, 6820, 6819, 6152, 
7437, 7968, 6094
2709, 1186, 625, 1187, 1308, 5029, 7347, 5141, 
5142, 5524, 5145
2710, 1246, 1207, 1155, 1245, 5938, 6152, 6093, 
4883, 7437, 6094
2711, 526, 457, 525, 1287, 2487, 2699, 2224, 
7335, 7334, 8079
2712, 1004, 1167, 1242, 1244, 6173, 7973, 7386, 
6466, 6465, 7528
2713, 43, 370, 799, 1137, 1713, 3155, 3154, 
4850, 4849, 5384
2714, 1344, 1347, 548, 1199, 6021, 7157, 8000, 
6396, 6451, 7377
2715, 185, 526, 525, 1287, 2039, 2224, 2038, 
8078, 7335, 8079
2716, 1335, 1195, 1192, 1331, 8041, 7426, 5533, 
7704, 7378, 7427
2717, 1221, 1161, 1225, 1218, 7417, 5675, 7535, 
7409, 8091, 7117
2718, 552, 551, 1140, 1353, 2250, 8093, 7074, 
7073, 8092, 5161
2719, 401, 951, 404, 959, 7155, 4043, 3862, 
6630, 4080, 4066
2720, 12, 500, 499, 1230, 1987, 2198, 1986, 
7318, 6540, 7718
2721, 936, 398, 943, 395, 6996, 4022, 6520, 
3950, 3853, 5526
2722, 1259, 695, 1175, 671, 5131, 5986, 6825, 
5130, 5132, 6204
2723, 1339, 1197, 1118, 1126, 7653, 6367, 5246, 
7873, 7872, 4817
2724, 570, 1259, 585, 455, 6945, 7549, 2321, 
2167, 5817, 2320
2725, 589, 647, 477, 1338, 2525, 2524, 2332, 
7886, 5290, 5291
2726, 1334, 1335, 1192, 1129, 5532, 5533, 5534, 
5412, 7703, 6736
2727, 500, 608, 499, 1230, 2388, 2387, 2198, 
6540, 6907, 7718
2728, 1224, 711, 1223, 1251, 5693, 5694, 5695, 
6342, 7154, 6345
2729, 1126, 1335, 1331, 1198, 5481, 7704, 8052, 
5480, 5110, 7380
2730, 295, 947, 932, 294, 4034, 6448, 6572, 
1623, 4035, 7840
2731, 1328, 1308, 295, 1333, 5474, 6682, 6375, 
6377, 5223, 6376
2732, 1248, 1168, 1169, 1223, 7982, 7639, 7006, 
7005, 7232, 6638
2733, 1308, 639, 1189, 626, 5478, 5479, 5477, 
5525, 2635, 5280
2734, 1255, 1254, 613, 510, 5904, 6644, 6632, 
5902, 5903, 2398
2735, 1344, 1337, 1194, 1343, 6404, 6622, 8094, 
6397, 6892, 6158
2736, 1343, 441, 1120, 442, 7662, 4784, 6157, 
6748, 1834, 4785
2737, 633, 632, 1197, 1336, 2554, 7641, 6737, 
7563, 8047, 7861
2738, 639, 478, 590, 1308, 2463, 2334, 2464, 
5478, 5446, 7033
2739, 723, 1198, 1336, 1197, 6046, 5945, 7624, 
7652, 7640, 7861
2740, 632, 633, 1197, 546, 2554, 6737, 7641, 
2439, 2440, 7430
2741, 861, 1199, 1345, 869, 5098, 6729, 6328, 
3543, 5100, 7052
2742, 1259, 80, 570, 672, 5816, 2137, 6945, 
6679, 2801, 7460
2743, 614, 1260, 615, 585, 8077, 7902, 2488, 
2656, 7579, 2630
2744, 20, 204, 548, 443, 1518, 2084, 2083, 
1836, 4830, 7212
2745, 509, 1252, 1254, 613, 5535, 5538, 5536, 
2397, 7351, 6644
2746, 1125, 1326, 788, 1330, 5842, 6696, 5370, 
6559, 6558, 7036
2747, 837, 1176, 1259, 847, 5353, 6961, 6960, 
3586, 8010, 6824
2748, 1353, 1350, 1203, 637, 7794, 6724, 7161, 
8095, 6723, 5046
2749, 1274, 714, 1174, 1275, 5567, 6565, 5343, 
4930, 5569, 5342
2750, 464, 705, 99, 271, 6288, 6290, 1885, 
7080, 2959, 2914
2751, 1349, 797, 798, 838, 5556, 3363, 5453, 
5454, 3409, 3435
2752, 551, 207, 1140, 1131, 2090, 4863, 8093, 
5790, 4833, 4853
2753, 1255, 1022, 1015, 1173, 7592, 4380, 7138, 
7602, 7217, 5220
2754, 1022, 1014, 1015, 1173, 4382, 4361, 4380, 
7217, 5219, 5220
2755, 1360, 28, 109, 3, 5843, 2911, 6803, 
6127, 1594, 1406
2756, 278, 735, 150, 312, 3199, 7725, 7752, 
3192, 3026, 4166
2757, 1363, 556, 810, 1151, 7485, 7487, 7162, 
5463, 7879, 7163
2758, 1176, 1173, 1174, 1257, 5577, 6915, 5355, 
5388, 5218, 6905
2759, 652, 1241, 501, 449, 5047, 6266, 2563, 
2564, 7320, 2522
2760, 581, 705, 597, 575, 6498, 5328, 2490, 
2294, 6289, 2489
2761, 1218, 1221, 972, 1225, 7409, 7536, 7118, 
7117, 7535, 6455
2762, 606, 1161, 1224, 483, 5673, 7866, 5677, 
2641, 6549, 6181
2763, 1289, 1288, 1285, 1284, 7755, 7757, 7915, 
7091, 7832, 7484
2764, 1277, 1188, 591, 133, 6252, 7582, 7683, 
6884, 7844, 2337
2765, 684, 1350, 94, 688, 7475, 7820, 2825, 
2849, 5396, 2848
2766, 1188, 650, 648, 591, 6114, 2539, 6115, 
7582, 2538, 2526
2767, 163, 1228, 499, 498, 7450, 8082, 1985, 
1984, 7147, 2197
2768, 720, 295, 721, 1189, 2994, 2995, 3274, 
6683, 6681, 8076
2769, 834, 878, 594, 872, 3709, 7432, 8042, 
3652, 3710, 6980
2770, 646, 1156, 1157, 602, 6868, 6049, 6869, 
2516, 7532, 6846
2771, 759, 1037, 1262, 1027, 6488, 6310, 6460, 
6512, 4446, 7593
2772, 560, 445, 21, 214, 5298, 1840, 2107, 
2108, 2700, 1531
2773, 278, 106, 312, 150, 2906, 8096, 3192, 
7752, 1895, 4166
2774, 24, 446, 220, 1358, 1842, 3847, 1539, 
6121, 4919, 5368
2775, 1218, 1216, 1217, 1160, 7333, 6533, 7410, 
7411, 6143, 7413
2776, 1037, 1039, 1262, 1027, 4464, 6308, 6310, 
4446, 4465, 7593
2777, 123, 258, 308, 257, 2868, 3198, 6712, 
2865, 1581, 3021
2778, 493, 9, 1355, 33, 1974, 7114, 6806, 
7870, 1795, 8097
2779, 1258, 1176, 1256, 847, 5390, 5391, 5389, 
6940, 8010, 6942
2780, 141, 302, 274, 140, 4146, 3011, 5373, 
1442, 4144, 8098
2781, 947, 955, 932, 939, 4079, 5235, 6448, 
6447, 5236, 4013
2782, 1313, 1093, 1311, 1086, 5228, 7830, 5613, 
5039, 4666, 7829
2783, 71, 665, 449, 1241, 2785, 8048, 1847, 
7862, 7119, 7320
2784, 278, 313, 312, 106, 2965, 1644, 3192, 
2906, 7306, 8096
2785, 1258, 758, 1037, 1262, 6939, 6336, 7492, 
6807, 6489, 6310
2786, 1324, 574, 1315, 582, 5516, 6830, 5431, 
5430, 2301, 5283
2787, 1126, 1123, 1340, 1197, 4805, 7657, 5482, 
7872, 7659, 7642
2788, 845, 856, 1314, 883, 3588, 6102, 6104, 
3679, 3645, 5708
2789, 518, 1293, 15, 428, 6068, 8072, 2023, 
6070, 5628, 1816
2790, 581, 705, 831, 726, 6498, 3391, 7010, 
6486, 3422, 3662
2791, 846, 581, 872, 726, 6485, 6978, 3734, 
3456, 6486, 3717
2792, 1180, 1181, 520, 1052, 4978, 5151, 7895, 
7743, 7810, 6886
2793, 951, 386, 950, 935, 4048, 4040, 4049, 
7082, 7164, 7084
2794, 1123, 1340, 1113, 1126, 7657, 5837, 4802, 
4805, 5482, 4806
2795, 875, 1332, 789, 1193, 5436, 7875, 3697, 
5432, 5434, 7937
2796, 1322, 459, 573, 679, 5287, 2157, 6223, 
5285, 5284, 8009
2797, 1315, 627, 582, 628, 5243, 2591, 5283, 
5090, 2590, 2592
2798, 514, 1041, 668, 1263, 6655, 6483, 7740, 
6656, 6482, 5262
2799, 845, 870, 883, 1314, 3707, 3698, 3679, 
6104, 7586, 5708
2800, 1314, 1324, 883, 1315, 5429, 7587, 5708, 
5428, 5431, 5707
2801, 735, 149, 312, 311, 7675, 4167, 3026, 
3027, 4175, 1643
2802, 514, 1041, 1025, 668, 6655, 4463, 7739, 
7740, 6483, 5650
2803, 1285, 772, 348, 773, 6781, 3100, 6670, 
6669, 3338, 3103
2804, 54, 49, 912, 895, 1746, 6507, 7556, 
3765, 3764, 7326
2805, 452, 1268, 1267, 516, 8099, 5188, 4948, 
2298, 7707, 7929
2806, 1158, 1156, 1211, 833, 6011, 5834, 5821, 
6014, 6012, 6052
2807, 384, 402, 63, 898, 3863, 1774, 3864, 
3775, 7464, 5369
2808, 386, 405, 51, 406, 4042, 1779, 1736, 
7129, 5617, 5618
2809, 187, 1070, 528, 1290, 4583, 6614, 2043, 
8017, 6612, 6439
2810, 386, 383, 406, 51, 3743, 5608, 7129, 
1736, 1731, 5618
2811, 243, 699, 1318, 784, 2940, 4990, 7145, 
3222, 3408, 4992
2812, 199, 1329, 543, 542, 7050, 8100, 2073, 
2072, 6705, 2241
2813, 1139, 1145, 1348, 1130, 4872, 7970, 5601, 
4859, 4873, 6317
2814, 1185, 82, 456, 571, 7913, 1867, 5216, 
7613, 2139, 2168
2815, 406, 383, 403, 51, 5608, 3865, 3882, 
5618, 1731, 3866
2816, 1263, 761, 668, 230, 7476, 6584, 5262, 
5261, 3208, 2730
2817, 68, 406, 403, 51, 1783, 3882, 1776, 
3871, 5618, 3866
2818, 728, 727, 465, 139, 3280, 5597, 5598, 
5696, 6031, 2181
2819, 826, 122, 256, 469, 7841, 2863, 3236, 
6463, 1913, 6823
2820, 515, 77, 514, 668, 2136, 2475, 2213, 
6294, 2792, 7740
2821, 1328, 845, 863, 721, 8101, 3601, 7645, 
6861, 3455, 3592
2822, 686, 1165, 451, 687, 6331, 6333, 6332, 
2846, 7291, 7882
2823, 493, 320, 468, 158, 7869, 7917, 2192, 
1973, 4186, 1972
2824, 1279, 622, 1278, 579, 7262, 7770, 5200, 
5202, 2606, 5201
2825, 1177, 1291, 1271, 850, 4899, 4876, 4902, 
7920, 6567, 5014
2826, 1185, 82, 673, 456, 7913, 2802, 5214, 
5216, 1867, 5215
2827, 809, 810, 1361, 378, 3372, 7823, 7950, 
3179, 3180, 6928
2828, 781, 1310, 856, 1313, 5720, 6715, 3484, 
5722, 5229, 6687
2829, 1270, 1068, 428, 427, 6000, 4573, 5629, 
7909, 4572, 1815
2830, 1201, 221, 580, 2, 6224, 7655, 6697, 
5209, 1540, 2296
2831, 221, 2, 96, 580, 1540, 1392, 2715, 
7655, 2296, 2293
2832, 451, 75, 686, 74, 1855, 2788, 6332, 
1853, 1370, 2789
2833, 641, 1171, 1165, 451, 5676, 6334, 7702, 
2473, 6335, 6333
2834, 450, 578, 1165, 451, 2282, 7701, 7384, 
1854, 2283, 6333
2835, 1273, 341, 1045, 765, 7761, 4482, 6877, 
7745, 3087, 7893
2836, 526, 83, 84, 675, 2141, 1379, 2142, 
7610, 2807, 2806
2837, 1287, 526, 84, 675, 7335, 2142, 6956, 
6957, 7610, 2806
2838, 691, 1235, 747, 818, 6493, 6495, 3570, 
3380, 4925, 3566
2839, 989, 1238, 998, 1005, 5960, 6302, 4301, 
4321, 7524, 4326
2840, 667, 229, 668, 1266, 2728, 2729, 2731, 
4951, 5795, 4954
2841, 608, 1165, 578, 1227, 7971, 7701, 2520, 
6908, 7003, 7009
2842, 618, 1274, 1181, 1276, 5716, 5719, 5149, 
6636, 7456, 5514
2843, 1348, 1130, 1145, 1141, 6317, 4873, 7970, 
6316, 4871, 4212
2844, 123, 122, 257, 147, 1421, 2866, 2865, 
1915, 1914, 6711
2845, 834, 32, 730, 488, 3282, 3015, 3283, 
6658, 6446, 6444
2846, 6, 134, 481, 413, 1434, 1942, 1941, 
1792, 3889, 7392
2847, 1297, 1302, 1301, 1298, 5732, 7801, 7355, 
7631, 7776, 7802
2848, 481, 30, 413, 290, 6592, 4942, 7392, 
6594, 1618, 4944
2849, 387, 413, 290, 897, 4941, 4944, 3757, 
3770, 4946, 3771
2850, 1187, 293, 294, 932, 6474, 1622, 5143, 
6170, 8045, 7840
2851, 4, 560, 1204, 554, 2166, 5300, 5667, 
2278, 2253, 7166
2852, 1167, 1244, 1155, 1242, 6465, 6092, 7449, 
7973, 7528, 7529
2853, 1274, 592, 1276, 638, 7905, 8002, 7456, 
4927, 2458, 8001
2854, 1348, 221, 865, 685, 7654, 6225, 5571, 
5590, 2828, 7498
2855, 808, 447, 377, 48, 5465, 3595, 3175, 
3176, 1843, 1723
2856, 684, 551, 95, 94, 8102, 2150, 2824, 
2825, 2149, 1390
2857, 483, 922, 135, 136, 7932, 3913, 1945, 
1946, 3915, 1436
2858, 684, 1202, 685, 95, 7816, 5592, 2779, 
2824, 6216, 2827
2859, 730, 488, 143, 487, 6444, 1956, 6445, 
6484, 2272, 1955
2860, 684, 551, 1202, 95, 8102, 5791, 7816, 
2824, 2150, 6216
2861, 1274, 592, 289, 1276, 7905, 4934, 7553, 
7456, 8002, 7670
2862, 1274, 592, 1252, 289, 7905, 7350, 7551, 
7553, 4934, 7014
2863, 618, 1274, 1276, 638, 5716, 7456, 6636, 
2557, 4927, 8001
2864, 584, 1199, 462, 634, 6450, 6238, 2497, 
2507, 7814, 2508
2865, 953, 945, 389, 411, 4053, 4030, 4051, 
5522, 8103, 7102
2866, 207, 551, 1140, 552, 2090, 8093, 4863, 
2091, 2250, 7074
2867, 152, 314, 736, 832, 4172, 3029, 6831, 
5501, 3292, 3291
2868, 1277, 1180, 1182, 716, 7319, 4973, 5063, 
6662, 6685, 6616
2869, 293, 930, 954, 294, 5250, 5757, 4055, 
1622, 5756, 4054
2870, 898, 402, 63, 55, 7464, 1774, 5369, 
6923, 3907, 1758
2871, 489, 834, 594, 488, 5546, 8042, 2343, 
2184, 6658, 2342
2872, 1170, 1007, 1254, 1020, 6873, 7030, 5540, 
7564, 4377, 7031
2873, 252, 468, 118, 117, 7846, 1905, 2855, 
2856, 1904, 1416
2874, 1278, 622, 523, 579, 7770, 2416, 5485, 
5201, 2606, 2586
2875, 515, 452, 76, 1267, 2279, 1857, 2135, 
6293, 4948, 6727
2876, 13, 178, 422, 517, 1487, 4406, 1808, 
2022, 2021, 5885
2877, 468, 157, 319, 118, 1971, 4181, 7847, 
1905, 1907, 7848
2878, 680, 1321, 1319, 681, 5104, 6691, 7153, 
2766, 7087, 6034
2879, 241, 680, 824, 242, 2761, 8049, 3221, 
1562, 2762, 3220
2880, 1039, 1028, 1263, 1027, 4470, 7025, 6785, 
4465, 4415, 6513
2881, 1070, 1068, 1292, 1074, 4584, 7244, 6613, 
4593, 4592, 7389
2882, 622, 1281, 524, 457, 7772, 8054, 2417, 
2657, 8083, 2696
2883, 1168, 508, 507, 611, 7278, 2206, 7279, 
7573, 2394, 2393
2884, 1105, 1321, 539, 1096, 8040, 6366, 6339, 
4731, 5312, 6340
2885, 1287, 1069, 1282, 1075, 6306, 6576, 5082, 
5081, 4599, 5083
2886, 843, 828, 1155, 26, 3505, 5769, 7447, 
3504, 3242, 5771
2887, 295, 720, 294, 1308, 2994, 2993, 1623, 
6682, 5175, 5144
2888, 100, 831, 271, 272, 4966, 3258, 2917, 
2894, 3257, 1598
2889, 925, 909, 910, 906, 6472, 3842, 6585, 
8069, 3824, 3840
2890, 1278, 622, 1281, 523, 7770, 7772, 5484, 
5485, 2416, 5487
2891, 831, 464, 730, 487, 4965, 6991, 3415, 
4967, 2288, 6484
2892, 529, 188, 15, 1293, 2045, 1499, 2046, 
7921, 8014, 8072
2893, 112, 111, 264, 839, 1409, 2890, 2882, 
8104, 8105, 3420
2894, 285, 284, 890, 917, 1612, 3752, 3751, 
5980, 6124, 5981
2895, 111, 1363, 556, 839, 8106, 7485, 2316, 
8105, 7486, 7488
2896, 518, 428, 15, 179, 6070, 1816, 2023, 
2024, 4472, 1488
2897, 1035, 177, 1267, 516, 4437, 6782, 5912, 
7928, 2019, 7929
2898, 1283, 1287, 526, 1069, 7341, 7335, 5473, 
5471, 6306, 5077
2899, 251, 467, 117, 116, 7489, 1903, 2853, 
2854, 1902, 1415
2900, 493, 320, 158, 33, 7869, 4186, 1973, 
7870, 1653, 4184
2901, 727, 7, 31, 733, 7264, 1793, 3008, 
3279, 5919, 3022
2902, 515, 177, 516, 1267, 2018, 2019, 2214, 
6293, 6782, 7929
2903, 527, 1289, 83, 1283, 7964, 5153, 2543, 
5917, 7089, 7609
2904, 1275, 850, 1273, 854, 5941, 5015, 6275, 
5570, 3546, 6274
2905, 132, 1187, 479, 590, 6169, 7898, 1937, 
2335, 8062, 2359
2906, 1289, 675, 83, 1283, 7100, 2807, 5153, 
7089, 7099, 7609
2907, 416, 159, 11, 494, 4187, 1464, 1800, 
7924, 1976, 1975
2908, 1160, 483, 484, 136, 6547, 2176, 7121, 
7359, 1946, 1947
2909, 452, 515, 516, 1267, 2279, 2214, 2298, 
4948, 6293, 7929
2910, 1290, 1283, 1284, 1289, 5742, 5745, 5743, 
8084, 7089, 7091
2911, 1066, 1291, 1288, 774, 7813, 6441, 7759, 
7584, 5971, 6665
2912, 1291, 696, 1185, 1288, 7860, 7919, 6425, 
6441, 6664, 5753
2913, 1035, 177, 516, 178, 4437, 2019, 7928, 
4436, 1486, 2020
2914, 1177, 655, 623, 1292, 6437, 2666, 7966, 
6427, 5975, 7992
2915, 1117, 1129, 1331, 1126, 4815, 7705, 7516, 
4816, 4820, 8052
2916, 741, 1158, 1211, 833, 5823, 5821, 5822, 
3582, 6014, 6052
2917, 467, 1354, 216, 22, 5443, 6346, 2115, 
2116, 5460, 1534
2918, 1070, 188, 187, 528, 4582, 1498, 4583, 
6614, 2044, 2043
2919, 33, 739, 734, 1355, 3034, 3289, 3025, 
8097, 8070, 6851
2920, 986, 1217, 1215, 984, 6531, 6413, 6281, 
4255, 5907, 6414
2921, 1297, 1302, 1089, 1301, 5732, 7854, 7354, 
7355, 7801, 6362
2922, 1322, 1105, 198, 1103, 7495, 4725, 5620, 
5326, 4727, 4717
2923, 474, 1208, 586, 1209, 8067, 8107, 2331, 
7925, 7435, 7471
2924, 484, 136, 917, 1160, 1947, 3893, 5560, 
7121, 7359, 7360
2925, 1335, 1129, 1126, 1331, 7703, 4820, 5481, 
7704, 7705, 8052
2926, 1270, 1269, 1177, 1271, 5156, 6946, 4901, 
4903, 5016, 4902
2927, 121, 815, 155, 255, 6822, 6415, 1911, 
2861, 3190, 5736
2928, 190, 531, 1304, 532, 2050, 7179, 7806, 
2051, 2230, 7808
2929, 1263, 453, 669, 77, 7741, 5293, 5260, 
5528, 1858, 2795
2930, 1159, 416, 1246, 494, 4884, 4885, 4886, 
5940, 7924, 4936
2931, 541, 434, 1103, 198, 7505, 4716, 5322, 
2069, 4692, 4717
2932, 513, 1024, 174, 175, 6322, 4403, 2013, 
2014, 4402, 1483
2933, 199, 1329, 542, 440, 7050, 6705, 2072, 
4759, 6704, 6706
2934, 606, 1160, 483, 605, 6546, 6547, 2641, 
2514, 6144, 2575
2935, 530, 1077, 189, 531, 6356, 4618, 2048, 
2229, 6354, 2049
2936, 121, 815, 469, 155, 6822, 6461, 1912, 
1911, 6415, 2169
2937, 485, 137, 282, 484, 1949, 6490, 5258, 
2177, 1948, 5559
2938, 617, 650, 1299, 1294, 2650, 6117, 6284, 
6285, 7169, 6287
2939, 434, 1077, 1301, 1089, 4648, 6359, 7747, 
4654, 4670, 6362
2940, 604, 1212, 646, 1156, 7699, 6870, 2517, 
5345, 6013, 6868
2941, 1113, 1123, 202, 1340, 4802, 4795, 4762, 
5837, 7657, 5838
2942, 1349, 1353, 1350, 1203, 7818, 7794, 5557, 
6755, 7161, 6724
2943, 790, 1116, 1331, 363, 6713, 8061, 5456, 
3136, 4772, 7519
2944, 452, 1268, 516, 577, 8099, 7707, 2298, 
2284, 5656, 2297
2945, 870, 845, 1205, 1314, 3707, 8109, 8108, 
7586, 6104, 5506
2946, 1074, 427, 1270, 1067, 4594, 7909, 7914, 
4605, 4571, 7910
2947, 203, 1123, 546, 202, 4794, 7660, 2080, 
1516, 4795, 2079
2948, 1363, 211, 1151, 1152, 5092, 2714, 5463, 
5094, 2713, 1898
2949, 1067, 1271, 426, 427, 4875, 7824, 4566, 
4571, 7908, 1814
2950, 1123, 1340, 546, 202, 7657, 7658, 7660, 
4795, 5838, 2079
2951, 760, 694, 230, 1263, 3649, 2930, 3580, 
6514, 5683, 5261
2952, 599, 586, 646, 1212, 2449, 2605, 2604, 
5711, 6971, 6870
2953, 1296, 617, 1301, 629, 5096, 7953, 5359, 
5097, 2480, 5360
2954, 116, 1354, 576, 250, 8037, 7075, 2323, 
2851, 7923, 7248
2955, 212, 1153, 558, 213, 2710, 7234, 2104, 
1529, 2703, 2103
2956, 567, 24, 220, 1358, 2125, 1539, 2126, 
6122, 6121, 5368
2957, 886, 1210, 740, 1207, 7020, 5826, 3726, 
7963, 6188, 6828
2958, 974, 835, 741, 1211, 6198, 3302, 5801, 
5814, 6200, 5822
2959, 1296, 617, 1294, 1301, 5096, 6285, 6286, 
5359, 7953, 7799
2960, 749, 1239, 690, 750, 5806, 6421, 3693, 
3314, 6429, 3675
2961, 996, 1206, 415, 1245, 7926, 5498, 4285, 
7967, 7717, 7713
2962, 911, 926, 910, 903, 6744, 6271, 3830, 
3826, 5553, 3821
2963, 508, 170, 171, 1016, 2003, 1478, 2004, 
7280, 4364, 4363
2964, 593, 482, 135, 1251, 2340, 1944, 2341, 
7325, 6550, 7500
2965, 1266, 228, 819, 686, 5796, 3206, 4904, 
4905, 2836, 4895
2966, 911, 926, 923, 910, 6744, 3944, 5760, 
3830, 6271, 6587
2967, 1362, 583, 558, 813, 6739, 2346, 7990, 
7236, 5876, 6718
2968, 1013, 756, 1173, 1012, 6975, 6916, 6976, 
4354, 4874, 7218
2969, 1295, 629, 1301, 541, 5351, 5360, 5361, 
5321, 2432, 7884
2970, 541, 1301, 434, 530, 7884, 7747, 7505, 
2240, 7749, 8004
2971, 263, 3, 28, 1361, 2879, 1594, 1587, 
7851, 6126, 6926
2972, 434, 1295, 1301, 541, 7746, 5361, 7747, 
7505, 5321, 7884
2973, 496, 1216, 604, 495, 5578, 5346, 2380, 
2194, 5310, 2379
2974, 882, 1107, 1317, 1316, 6206, 6208, 6207, 
7543, 6364, 7337
2975, 591, 1187, 479, 133, 7581, 7898, 2336, 
2337, 6168, 1938
2976, 1322, 1190, 541, 459, 5289, 7839, 5323, 
5287, 5288, 2512
2977, 537, 1095, 536, 194, 6721, 8110, 2235, 
2061, 4689, 2060
2978, 302, 139, 301, 728, 4145, 4153, 1631, 
3009, 5696, 3010
2979, 123, 308, 146, 147, 6712, 4157, 1962, 
1915, 4159, 1449
2980, 1095, 1316, 536, 437, 6007, 5797, 8110, 
4720, 5004, 6002
2981, 1184, 238, 677, 697, 8015, 2753, 5011, 
4964, 2936, 5012
2982, 1184, 238, 676, 677, 8015, 2752, 6837, 
5011, 2753, 2755
2983, 1184, 676, 822, 1286, 6837, 7604, 8016, 
7679, 6598, 5107
2984, 1157, 1208, 1209, 586, 6848, 7435, 7434, 
6882, 8107, 7471
2985, 563, 1356, 816, 468, 5789, 8051, 7373, 
2544, 8111, 7918
2986, 1213, 971, 986, 982, 5448, 4240, 8112, 
7451, 4239, 4241
2987, 1303, 1302, 1305, 1294, 7853, 7883, 7596, 
7887, 7798, 7424
2988, 390, 410, 392, 52, 5519, 7514, 3760, 
1741, 7513, 1744
2989, 7, 491, 492, 733, 2171, 2170, 1964, 
5919, 6999, 6067
2990, 293, 133, 1187, 1188, 5248, 6168, 6474, 
8044, 7844, 6605
2991, 277, 276, 832, 105, 1603, 3263, 3262, 
2904, 2901, 5502
2992, 1133, 1134, 796, 367, 4576, 7504, 7317, 
4840, 4841, 3149
2993, 586, 709, 1212, 599, 7894, 5710, 6971, 
2449, 5580, 5711
2994, 837, 1176, 847, 880, 5353, 8010, 3586, 
3742, 6553, 3674
2995, 790, 1332, 789, 875, 5455, 7875, 3355, 
3637, 5436, 3697
2996, 908, 907, 919, 901, 3814, 5886, 7348, 
3813, 3809, 5887
2997, 591, 1187, 595, 479, 7581, 7345, 2345, 
2336, 7898, 2344
2998, 761, 760, 1029, 338, 3326, 5915, 6542, 
3079, 3076, 4416
2999, 1240, 1236, 1239, 664, 7123, 5807, 7124, 
6040, 6527, 8011
3000, 48, 809, 1361, 378, 3178, 7950, 7664, 
1724, 3179, 6928
3001, 969, 941, 939, 967, 5488, 4017, 6086, 
4133, 5490, 7018
3002, 1332, 722, 1331, 1192, 5458, 5459, 5457, 
5437, 7425, 7427
3003, 793, 861, 1345, 869, 3499, 6328, 4995, 
3541, 3543, 7052
3004, 1187, 133, 293, 932, 6168, 5248, 6474, 
6170, 4001, 8045
3005, 508, 1250, 1168, 1016, 7457, 5927, 7278, 
7280, 7643, 5738
3006, 269, 25, 704, 689, 1595, 2958, 2957, 
2920, 2919, 7562
3007, 702, 126, 472, 260, 5340, 1921, 5070, 
2953, 2870, 5071
3008, 126, 127, 472, 260, 1425, 1922, 1921, 
2870, 2869, 5071
3009, 127, 827, 472, 260, 7507, 5069, 1922, 
2869, 3241, 5071
3010, 1316, 682, 460, 683, 5931, 5934, 5932, 
5735, 2772, 6001
3011, 194, 1095, 536, 437, 4689, 8110, 2060, 
4687, 4720, 6002
3012, 1339, 1126, 1117, 1331, 7873, 4816, 5245, 
8053, 8052, 7516
3013, 1157, 1208, 1207, 886, 6848, 6148, 6849, 
7022, 7510, 7963
3014, 1198, 791, 1331, 1339, 6045, 7518, 7380, 
6047, 4957, 8053
3015, 1164, 226, 818, 666, 7134, 3204, 7132, 
7712, 2725, 7891
3016, 1095, 1316, 537, 536, 6007, 6719, 6721, 
8110, 5797, 2235
3017, 1362, 813, 812, 830, 7236, 3376, 6732, 
6733, 3737, 3736
3018, 914, 896, 905, 888, 6982, 3804, 6835, 
5873, 3768, 3823
3019, 846, 878, 872, 657, 3733, 3710, 3734, 
6981, 7431, 6979
3020, 1127, 1329, 1193, 1334, 5177, 5727, 8026, 
5411, 5726, 5730
3021, 371, 1204, 1354, 801, 5648, 6799, 6654, 
3158, 5665, 6652
3022, 1313, 534, 535, 1086, 5782, 2233, 5244, 
5039, 5839, 5829
3023, 321, 835, 983, 740, 3300, 6199, 4230, 
3036, 3301, 5824
3024, 574, 93, 245, 92, 2148, 2773, 6688, 
2147, 1388, 2850
3025, 756, 1253, 755, 713, 6964, 6220, 3321, 
3464, 6965, 3465
3026, 1262, 1264, 1175, 670, 6894, 8032, 6810, 
6476, 7024, 6205
3027, 1264, 1262, 1175, 1261, 6894, 6810, 8032, 
6897, 6811, 6812
3028, 1198, 791, 722, 1331, 6045, 3633, 7381, 
7380, 7518, 5459
3029, 98, 270, 99, 575, 2912, 2913, 1395, 
2155, 7865, 2153
3030, 427, 1178, 428, 1270, 8113, 5630, 1815, 
7909, 5157, 5629
3031, 801, 1204, 800, 371, 5665, 5649, 3160, 
3158, 5648, 3157
3032, 1334, 1329, 1112, 1127, 5726, 7051, 7368, 
5411, 5177, 4819
3033, 412, 929, 945, 965, 3957, 6232, 7044, 
7043, 5135, 4108
3034, 137, 485, 282, 915, 1949, 5258, 6490, 
3929, 5603, 6315
3035, 500, 1233, 652, 608, 6539, 5048, 2565, 
2388, 7282, 2655
3036, 1184, 852, 1278, 1280, 4961, 7907, 7771, 
7676, 7987, 5880
3037, 1190, 87, 459, 679, 7636, 1873, 5288, 
5286, 2815, 5284
3038, 540, 1321, 573, 539, 8038, 5102, 2509, 
2238, 6366, 2492
3039, 1322, 1319, 1320, 679, 6689, 5416, 6263, 
5285, 7065, 7889
3040, 368, 797, 369, 1135, 3151, 3150, 1711, 
4843, 6075, 4844
3041, 1334, 1329, 543, 1112, 5726, 8100, 6108, 
7368, 7051, 7367
3042, 1306, 874, 293, 718, 5643, 3575, 6917, 
7416, 3574, 2990
3043, 1164, 450, 652, 608, 7574, 2569, 6741, 
7283, 2519, 2655
3044, 634, 1344, 1342, 548, 6401, 6403, 5511, 
2443, 8000, 5509
3045, 1198, 791, 723, 722, 6045, 3495, 6046, 
7381, 3633, 3579
3046, 1306, 293, 719, 1187, 6917, 2991, 5646, 
6606, 6474, 6475
3047, 1198, 722, 723, 297, 7381, 3579, 6046, 
7627, 2998, 2999
3048, 1308, 625, 1187, 590, 5524, 7347, 5145, 
7033, 2459, 8062
3049, 1197, 1123, 1128, 1126, 7659, 4810, 7734, 
7872, 4805, 4811
3050, 540, 1322, 541, 459, 5619, 5323, 2239, 
2511, 5287, 2512
3051, 1186, 294, 1187, 719, 5140, 5143, 5141, 
6629, 2992, 6475
3052, 1297, 1079, 432, 433, 7858, 4625, 5339, 
7356, 4624, 1822
3053, 508, 1007, 1170, 1016, 6871, 6873, 6872, 
7280, 4372, 7980
3054, 872, 834, 730, 594, 3652, 3283, 3567, 
6980, 8042, 7109
3055, 904, 56, 920, 924, 6194, 3924, 7198, 
7404, 3922, 3928
3056, 141, 103, 140, 274, 1889, 2307, 1442, 
5373, 2897, 8098
3057, 749, 328, 993, 329, 3055, 4274, 5802, 
3054, 1663, 4275
3058, 1319, 698, 824, 786, 7067, 3385, 7064, 
6801, 3511, 3488
3059, 1170, 1016, 1023, 1250, 7980, 4397, 7565, 
7550, 7643, 7644
3060, 390, 953, 389, 411, 4052, 4051, 1740, 
5520, 5522, 7102
3061, 1323, 1205, 1193, 1329, 6006, 7785, 7782, 
5024, 6647, 5727
3062, 1113, 1335, 1122, 1129, 7767, 7769, 4801, 
4821, 7703, 4826
3063, 1348, 96, 550, 580, 7719, 2152, 5591, 
7093, 2293, 2292
3064, 4, 116, 576, 250, 1414, 2323, 2322, 
2852, 2851, 7248
3065, 452, 1268, 577, 1266, 8099, 5656, 2284, 
4952, 5191, 7531
3066, 1007, 1023, 1170, 1016, 4392, 7565, 6873, 
4372, 4397, 7980
3067, 739, 804, 734, 1355, 3413, 3412, 3289, 
8070, 5364, 6851
3068, 1315, 92, 574, 245, 5686, 2147, 6830, 
5238, 2850, 6688
3069, 694, 759, 1262, 1263, 3648, 6460, 6459, 
5683, 6515, 6477
3070, 1127, 1329, 1323, 1193, 5177, 5024, 5176, 
8026, 5727, 7782
3071, 925, 900, 909, 906, 6470, 3817, 6472, 
8069, 3805, 3824
3072, 5, 409, 486, 138, 1787, 6821, 1952, 
1439, 3888, 1951
3073, 1220, 658, 1222, 607, 5974, 7983, 7076, 
5964, 2623, 7167
3074, 1169, 1006, 1168, 1018, 7395, 5737, 7639, 
8003, 4383, 7470
3075, 1171, 577, 1268, 1266, 5658, 5656, 5657, 
4906, 7531, 5191
3076, 1013, 1014, 1012, 1173, 4357, 4388, 4354, 
6976, 5219, 7218
3077, 1190, 787, 1320, 1295, 7541, 7482, 8081, 
7228, 6921, 5037
3078, 1181, 519, 520, 1052, 5150, 2218, 5151, 
7810, 7811, 6886
3079, 975, 742, 323, 1214, 7724, 3040, 4200, 
7716, 6280, 7462
3080, 1268, 178, 1035, 516, 7465, 4436, 5911, 
7707, 2020, 7928
3081, 1061, 527, 1290, 187, 5918, 5916, 5744, 
4546, 2042, 8017
3082, 1069, 1061, 186, 1283, 4581, 4547, 4580, 
5471, 5746, 5472
3083, 742, 743, 323, 1214, 3305, 3043, 3040, 
6280, 6249, 7462
3084, 519, 1272, 1042, 1179, 7728, 6085, 7805, 
6563, 4892, 6084
3085, 1287, 1281, 457, 525, 7825, 8083, 7334, 
8079, 8087, 2699
3086, 1069, 185, 1060, 1287, 4578, 4544, 4579, 
6306, 8078, 6307
3087, 1043, 1056, 1053, 1182, 4519, 4518, 4515, 
4989, 6624, 6072
3088, 1280, 1072, 1062, 1286, 8114, 4611, 7857, 
7677, 8115, 8034
3089, 1280, 430, 1278, 1281, 7855, 5740, 5880, 
8013, 7774, 5484
3090, 322, 742, 323, 975, 3041, 3040, 1656, 
4199, 7724, 4200
3091, 37, 420, 763, 752, 1805, 6856, 3082, 
3061, 6974, 3316
3092, 1205, 788, 858, 1327, 6703, 3490, 7976, 
5778, 6702, 7668
3093, 1043, 1180, 520, 1052, 4987, 7895, 6885, 
4514, 7743, 6886
3094, 518, 610, 1272, 519, 2391, 7730, 6069, 
2217, 2392, 7728
3095, 440, 553, 208, 1138, 7085, 2093, 4835, 
4855, 6751, 4856
3096, 1043, 1182, 1053, 521, 4989, 6072, 4515, 
4988, 4975, 6074
3097, 524, 431, 184, 1060, 5054, 4543, 2036, 
8028, 4577, 4545
3098, 418, 1231, 990, 1232, 7751, 7838, 4267, 
7196, 7955, 7956
3099, 870, 788, 858, 1205, 3547, 3490, 3548, 
8108, 6703, 7976
3100, 1262, 820, 670, 1175, 6458, 6496, 6476, 
6810, 5987, 6205
3101, 423, 1258, 758, 1037, 6814, 6939, 7790, 
4408, 7492, 6336
3102, 438, 439, 1137, 1325, 1830, 4570, 4851, 
7695, 5377, 5380
3103, 1227, 848, 879, 1163, 5889, 3638, 7438, 
5892, 5890, 7058
3104, 1181, 1046, 766, 1045, 4979, 7175, 5405, 
7867, 4486, 7176
3105, 409, 958, 300, 29, 6763, 4063, 6161, 
5367, 4062, 1629
3106, 771, 346, 1072, 1063, 3099, 4587, 6543, 
8116, 4553, 4595
3107, 1057, 1273, 1044, 1055, 6875, 7764, 4521, 
4535, 7600, 4538
3108, 1226, 977, 1162, 985, 7939, 7419, 6778, 
7253, 4247, 7308
3109, 346, 771, 347, 1063, 3099, 3098, 1685, 
4553, 8116, 4554
3110, 1326, 1323, 1205, 1330, 6925, 6006, 5776, 
6558, 7781, 7783
3111, 1063, 772, 771, 347, 6933, 3337, 8116, 
4554, 3101, 3098
3112, 139, 727, 301, 728, 6031, 3007, 4153, 
5696, 3280, 3010
3113, 555, 556, 1361, 110, 2257, 7850, 8117, 
2162, 2315, 8118
3114, 1192, 875, 1328, 1193, 5435, 7646, 7706, 
5433, 5432, 5729
3115, 1333, 1328, 649, 1192, 6377, 7363, 5421, 
7878, 7706, 7877
3116, 1096, 1321, 1104, 1108, 5312, 7415, 4724, 
4733, 5313, 4734
3117, 1305, 1080, 352, 777, 4915, 4627, 4917, 
7231, 7766, 3110
3118, 1195, 296, 1333, 1192, 7988, 6374, 6100, 
7426, 8119, 7878
3119, 160, 159, 971, 495, 1465, 4189, 4188, 
1978, 1977, 5449
3120, 925, 914, 889, 905, 3945, 7440, 6260, 
6836, 6835, 3803
3121, 1228, 163, 499, 1230, 7450, 1985, 8082, 
7180, 7972, 7718
3122, 988, 1234, 1000, 1003, 7681, 7962, 4313, 
4319, 7273, 4307
3123, 1237, 746, 1231, 1001, 6844, 5968, 7296, 
6843, 5969, 5967
3124, 71, 449, 569, 1241, 1847, 2172, 2134, 
7862, 7320, 6303
3125, 1212, 282, 709, 283, 5709, 2971, 5710, 
8071, 1610, 2972
3126, 512, 511, 14, 425, 2210, 2010, 2011, 
7148, 7048, 1812
3127, 1172, 611, 593, 612, 7837, 2668, 7985, 
5256, 2518, 2456
3128, 1261, 511, 1257, 615, 7045, 6967, 7046, 
6834, 2401, 7998
3129, 875, 1332, 1192, 722, 5436, 5437, 5435, 
3636, 5458, 7425
3130, 427, 1178, 1054, 428, 8113, 7949, 4511, 
1815, 5630, 4510
3131, 1305, 777, 352, 778, 7231, 3110, 4917, 
5767, 3343, 3113
3132, 442, 1194, 1344, 1121, 7737, 8094, 6747, 
4787, 8024, 7731
3133, 515, 76, 77, 668, 2135, 1372, 2136, 
6294, 2793, 2792
3134, 136, 285, 1160, 483, 7358, 6505, 7359, 
1946, 7931, 6547
3135, 1194, 1121, 1342, 1344, 8024, 7649, 6619, 
8094, 7731, 6403
3136, 529, 1293, 15, 518, 7921, 8072, 2046, 
2228, 6068, 2023
3137, 1237, 990, 1001, 1231, 8063, 4325, 6843, 
7296, 7838, 5967
3138, 940, 966, 941, 968, 7260, 7684, 4011, 
5183, 4124, 5489
3139, 1003, 991, 1237, 1001, 4323, 5168, 5166, 
4322, 4304, 6843
3140, 610, 518, 1272, 644, 2391, 6069, 7730, 
2485, 2484, 6079
3141, 1118, 1120, 1341, 1119, 4818, 5371, 6368, 
4783, 4786, 5372
3142, 1125, 1127, 1330, 1115, 4822, 8027, 6559, 
4804, 4823, 7934
3143, 1194, 1121, 1197, 1342, 8024, 7733, 6621, 
6619, 7649, 6620
3144, 251, 467, 116, 701, 7489, 1902, 2854, 
2943, 5444, 8033
3145, 530, 434, 541, 17, 8004, 7505, 2240, 
2047, 1824, 2070
3146, 875, 296, 722, 1192, 3578, 2997, 3636, 
5435, 8119, 7425
3147, 903, 56, 924, 912, 6193, 3922, 5555, 
5554, 3878, 3923
3148, 808, 447, 1359, 377, 5465, 5468, 5466, 
3175, 3595, 5996
3149, 809, 808, 48, 1361, 3373, 3176, 3178, 
7950, 5467, 7664
3150, 296, 297, 722, 1195, 1625, 2998, 2997, 
7988, 6098, 7379
3151, 406, 951, 405, 400, 7128, 4044, 5617, 
3969, 7689, 3869
3152, 1313, 1093, 1310, 1311, 5228, 5231, 5229, 
5613, 7830, 5615
3153, 1277, 1180, 619, 1182, 7319, 4971, 5139, 
5063, 4973, 4974
3154, 617, 530, 1303, 1301, 2406, 6358, 7952, 
7953, 7749, 6361
3155, 633, 1342, 546, 547, 6675, 7429, 2440, 
2441, 5510, 2245
3156, 1335, 1113, 201, 545, 7767, 4763, 7768, 
6270, 5835, 2077
3157, 1347, 204, 1130, 443, 6626, 4832, 5124, 
5125, 4830, 4857
3158, 1127, 1332, 1193, 1115, 7708, 5434, 8026, 
4823, 7874, 7936
3159, 545, 1335, 544, 201, 6270, 6269, 2243, 
2077, 7768, 2076
3160, 1326, 438, 43, 1327, 5840, 1829, 6695, 
5774, 7694, 7068
3161, 903, 56, 912, 54, 6193, 3878, 5554, 
3792, 1749, 7556
3162, 111, 1363, 557, 556, 8106, 8120, 2317, 
2316, 7485, 2258
3163, 453, 1263, 669, 670, 7741, 5260, 5293, 
5294, 5685, 2737
3164, 1342, 203, 546, 547, 7647, 2080, 7429, 
5510, 2081, 2245
3165, 863, 1205, 1193, 1330, 8023, 7785, 7999, 
8046, 7783, 7784
3166, 630, 1335, 544, 631, 5529, 6269, 2435, 
2581, 5512, 2436
3167, 975, 1214, 323, 976, 7716, 7462, 4200, 
4204, 7461, 4202
3168, 212, 1362, 466, 558, 5724, 5951, 2260, 
2104, 7990, 2259
3169, 392, 394, 393, 920, 3859, 1761, 3858, 
7590, 3903, 3902
3170, 460, 1316, 640, 537, 5932, 5252, 2468, 
2403, 6719, 2467
3171, 1264, 453, 514, 513, 7742, 2613, 7735, 
6323, 2645, 2212
3172, 1167, 1002, 994, 1239, 6171, 4317, 6172, 
6419, 7324, 8036
3173, 94, 93, 688, 637, 1389, 2842, 2848, 
2450, 2452, 5043
3174, 1324, 1205, 1191, 636, 7977, 7969, 6694, 
5518, 6648, 7276
3175, 1114, 1127, 1323, 1330, 4808, 5176, 7686, 
6557, 8027, 7781
3176, 506, 1006, 169, 507, 7399, 4332, 2000, 
2205, 7398, 2001
3177, 1176, 1261, 1257, 615, 7786, 7046, 5388, 
7903, 6834, 7998
3178, 661, 610, 1275, 644, 2686, 4928, 6422, 
2685, 2485, 5850
3179, 1179, 1044, 1273, 1178, 7947, 7764, 6273, 
4889, 7948, 8080
3180, 1197, 1120, 1341, 1118, 7721, 5371, 6370, 
6367, 4818, 6368
3181, 629, 541, 1295, 572, 2432, 5321, 5351, 
2566, 2619, 7230
3182, 1039, 1041, 1034, 1263, 4471, 4468, 4466, 
6785, 6482, 6657
3183, 1167, 222, 690, 843, 5989, 2922, 6420, 
5991, 3447, 3446
3184, 474, 262, 1209, 128, 6497, 7981, 7925, 
1927, 2874, 7472
3185, 167, 1240, 999, 504, 6063, 6064, 4295, 
1995, 6312, 7321
3186, 514, 1041, 1034, 1025, 6655, 4468, 6276, 
7739, 4463, 4443
3187, 1164, 226, 692, 818, 7134, 2926, 7133, 
7132, 3204, 3395
3188, 941, 967, 968, 960, 5490, 4142, 5489, 
7656, 4113, 4131
3189, 364, 1117, 363, 791, 4775, 4774, 1705, 
3138, 7517, 3139
3190, 1308, 132, 1187, 932, 5224, 6169, 5145, 
5225, 3966, 6170
3191, 791, 790, 722, 1331, 3356, 3634, 3633, 
7518, 5456, 5459
3192, 1036, 1024, 425, 1261, 4455, 4433, 4439, 
6896, 7727, 7047
3193, 1243, 842, 751, 740, 6818, 3445, 5988, 
6827, 3444, 3303
3194, 78, 79, 454, 670, 1374, 1861, 1860, 
2797, 2796, 7700
3195, 1024, 512, 425, 1261, 8074, 7148, 4433, 
7727, 6832, 7047
3196, 268, 559, 560, 115, 5315, 2262, 5316, 
2889, 2164, 2165
3197, 506, 1006, 422, 169, 7399, 4362, 7314, 
2000, 4332, 4330
3198, 441, 1343, 1120, 1341, 7662, 6157, 4784, 
4998, 6160, 5371
3199, 86, 1279, 458, 677, 7632, 7173, 1871, 
2810, 5010, 7174
3200, 559, 813, 1154, 558, 6390, 7509, 7661, 
2261, 6718, 7235
3201, 551, 1350, 1353, 637, 7821, 7794, 8092, 
2451, 6723, 8095
3202, 985, 981, 1162, 1228, 4236, 7287, 7308, 
7251, 7149, 6775
3203, 1312, 1311, 1091, 1186, 7342, 7364, 7626, 
7343, 5278, 8088
3204, 1228, 985, 979, 1229, 7251, 4235, 7181, 
7182, 7254, 7185
3205, 474, 596, 609, 1155, 2454, 2472, 2462, 
6903, 7672, 6226
3206, 840, 109, 1358, 280, 6757, 6134, 6758, 
3426, 2909, 6178
3207, 651, 1189, 534, 627, 6674, 5282, 2558, 
2559, 5768, 2428
3208, 1342, 1337, 1194, 1344, 6405, 6622, 6619, 
6403, 6404, 8094
3209, 221, 25, 865, 249, 1541, 3521, 6225, 
2716, 1570, 3518
3210, 626, 639, 590, 1308, 2635, 2464, 2636, 
5525, 5478, 7033
3211, 816, 320, 319, 468, 3196, 1652, 3193, 
7918, 7917, 7847
3212, 1139, 1348, 1145, 1142, 5601, 7970, 4872, 
4869, 5587, 4116
3213, 1091, 1088, 1311, 1093, 4662, 5273, 7364, 
4668, 4667, 7830
3214, 362, 361, 789, 1115, 1703, 3135, 3134, 
4770, 4769, 7876
3215, 1169, 662, 1223, 603, 6637, 6640, 6638, 
7403, 2663, 7859
3216, 1300, 1296, 853, 1295, 5347, 5217, 7560, 
5349, 5348, 8121
3217, 1267, 1265, 668, 1038, 5187, 6583, 4953, 
5653, 7577, 5652
3218, 1351, 1138, 439, 1144, 6749, 4854, 5376, 
7819, 4870, 4569
3219, 793, 441, 44, 1119, 4994, 1833, 3142, 
7098, 4782, 4781
3220, 1289, 82, 571, 83, 5152, 2139, 7965, 
5153, 1378, 2140
3221, 1275, 850, 1269, 1273, 5941, 5013, 5851, 
6275, 5015, 5017
3222, 1177, 1293, 1270, 1292, 7945, 5626, 4901, 
6427, 7243, 7245
3223, 824, 679, 680, 241, 7063, 2763, 8049, 
3221, 2760, 2761
3224, 1272, 644, 1269, 1275, 6079, 5849, 6010, 
4890, 5850, 5851
3225, 1072, 771, 1063, 1286, 6543, 8116, 4595, 
8115, 5106, 6934
3226, 900, 925, 891, 922, 6470, 6471, 3799, 
7566, 3934, 8007
3227, 662, 658, 1222, 1223, 2676, 7983, 8075, 
6640, 5973, 7110
3228, 368, 1134, 796, 1135, 4842, 7504, 3148, 
4843, 4845, 6077
3229, 416, 159, 494, 1213, 4187, 1976, 7924, 
5669, 5668, 7441
3230, 1353, 1349, 1350, 1146, 7818, 5557, 7794, 
5160, 7666, 7795
3231, 573, 680, 679, 88, 5103, 2763, 8009, 
2145, 2817, 2814
3232, 87, 88, 459, 679, 1383, 1874, 1873, 
2815, 2814, 5284
3233, 1321, 1105, 1111, 1096, 8040, 4749, 5314, 
5312, 4731, 4750
3234, 1171, 849, 763, 1247, 5595, 3463, 8059, 
5984, 5858, 6790
3235, 1083, 1084, 780, 355, 4640, 7428, 7408, 
4635, 4637, 3116
3236, 784, 824, 785, 1319, 3538, 3489, 3350, 
6035, 7064, 7508
3237, 602, 1208, 586, 609, 6845, 8107, 2652, 
2577, 6227, 2461
3238, 211, 210, 556, 1151, 1527, 2100, 2099, 
2714, 2548, 7879
3239, 694, 669, 231, 230, 5682, 2733, 2929, 
2930, 2732, 1551
3240, 111, 1363, 112, 557, 8106, 7539, 1409, 
2317, 8120, 2318
3241, 793, 794, 44, 1345, 3359, 3145, 3142, 
4995, 6327, 7469
3242, 214, 559, 1154, 213, 2105, 7661, 2701, 
1530, 2106, 2702
3243, 813, 1153, 1154, 558, 6765, 2270, 7509, 
6718, 7234, 7235
3244, 1278, 523, 1183, 579, 5485, 5072, 7103, 
5201, 2586, 7104
3245, 781, 1310, 780, 856, 5720, 6579, 3346, 
3484, 6715, 3485
3246, 643, 617, 659, 1299, 2482, 2633, 2632, 
7789, 6284, 7540
3247, 1190, 87, 678, 572, 7636, 2812, 7637, 
7229, 2144, 8058
3248, 643, 1300, 572, 629, 6392, 7227, 2531, 
2481, 5350, 2566
3249, 1303, 617, 1294, 531, 7952, 6285, 7887, 
6355, 2407, 7170
3250, 1279, 86, 572, 678, 7632, 2143, 7633, 
8057, 2813, 8058
3251, 886, 1157, 828, 833, 7022, 6202, 3738, 
3735, 6050, 3591
3252, 1047, 768, 767, 344, 8065, 3333, 7897, 
4488, 3093, 3090
3253, 441, 366, 1345, 44, 4836, 7309, 4997, 
1833, 1708, 7469
3254, 274, 728, 275, 103, 3197, 3260, 1601, 
2897, 5734, 2900
3255, 148, 826, 733, 492, 6453, 3389, 5409, 
1963, 6462, 6067
3256, 1170, 755, 1253, 877, 6217, 6220, 6218, 
7589, 3695, 7239
3257, 706, 728, 465, 275, 3397, 5598, 5596, 
2964, 3260, 5276
3258, 1276, 1180, 30, 715, 5513, 6938, 6595, 
5515, 5402, 2984
3259, 1295, 1190, 1322, 1320, 7228, 5289, 5325, 
5037, 8081, 6263
3260, 116, 467, 1354, 701, 1902, 5443, 8037, 
8033, 5444, 5445
3261, 535, 628, 437, 536, 2430, 5275, 5274, 
2234, 2431, 6002
3262, 1202, 1146, 1350, 1135, 8122, 7795, 7817, 
6076, 4138, 7691
3263, 563, 1356, 802, 816, 5789, 5788, 5783, 
7373, 8051, 3517
3264, 133, 1188, 291, 1277, 7844, 8035, 8086, 
6884, 6252, 7842
3265, 133, 1277, 480, 591, 6884, 5138, 1939, 
2337, 7683, 2360
3266, 718, 292, 293, 1188, 2989, 1621, 2990, 
5264, 5265, 8044
3267, 760, 1028, 338, 337, 5914, 4414, 3076, 
3077, 4413, 1674
3268, 595, 650, 1188, 591, 2537, 6114, 7583, 
2345, 2538, 7582
3269, 262, 703, 828, 1209, 2955, 3390, 3243, 
7981, 7979, 7433
3270, 625, 479, 1187, 590, 2460, 7898, 7347, 
2459, 2359, 8062
3271, 1210, 1213, 986, 982, 7927, 8112, 5794, 
5793, 7451, 4241
3272, 595, 1294, 1187, 1188, 7168, 6604, 7345, 
7583, 6607, 6605
3273, 7, 727, 139, 491, 7264, 6031, 1440, 
2171, 6998, 2180
3274, 727, 465, 139, 491, 5597, 2181, 6031, 
6998, 2357, 2180
3275, 740, 835, 983, 1211, 3301, 6199, 5824, 
5827, 6200, 5815
3276, 1348, 1202, 685, 796, 5588, 5592, 5590, 
5572, 5612, 7497
3277, 1265, 339, 1029, 1030, 6138, 4417, 7576, 
6140, 4419, 4421
3278, 727, 706, 465, 491, 3442, 5596, 5597, 
6998, 6393, 2357
3279, 248, 685, 796, 249, 2777, 7497, 3229, 
1569, 2778, 3228
3280, 209, 576, 1354, 1204, 2256, 7075, 5462, 
6798, 8123, 6799
3281, 742, 1215, 322, 741, 6279, 5800, 3041, 
3298, 5799, 3038
3282, 797, 1135, 1202, 1350, 6075, 6076, 5611, 
5558, 7691, 7817
3283, 236, 1285, 1282, 674, 6780, 7029, 7369, 
2747, 7615, 7370
3284, 865, 249, 796, 685, 3518, 3228, 3519, 
7498, 2778, 7497
3285, 963, 970, 964, 939, 4140, 4121, 4141, 
6088, 6087, 6710
3286, 1178, 1275, 1273, 1179, 4887, 6275, 8080, 
4889, 4891, 6273
3287, 1104, 539, 196, 538, 6353, 2065, 4723, 
7778, 2237, 2064
3288, 504, 1240, 448, 503, 6312, 7961, 2669, 
2202, 5961, 2536
3289, 463, 462, 704, 598, 1884, 6215, 5867, 
2356, 2355, 5868
3290, 1272, 1178, 1275, 1269, 4888, 4887, 4890, 
6010, 5158, 5851
3291, 1145, 1143, 1348, 1141, 4115, 5397, 7970, 
4212, 4213, 6316
3292, 1238, 70, 1240, 503, 6037, 6039, 5958, 
5959, 2535, 5961
3293, 1333, 132, 131, 478, 5221, 1431, 7268, 
5419, 1936, 1935
3294, 1293, 1177, 1269, 623, 7945, 6946, 5994, 
7922, 7966, 7298
3295, 973, 1210, 414, 983, 5792, 5495, 4196, 
4254, 5825, 4194
3296, 484, 1212, 646, 604, 7698, 6870, 2665, 
2684, 7699, 2517
3297, 1263, 453, 514, 1264, 7741, 2613, 6656, 
6784, 7742, 7735
3298, 1264, 512, 513, 1024, 8073, 2211, 6323, 
6325, 8074, 6322
3299, 468, 739, 1356, 816, 7916, 6291, 8111, 
7918, 3233, 8051
3300, 468, 739, 493, 1356, 7916, 7871, 2192, 
8111, 6291, 6805
3301, 1264, 512, 454, 513, 8073, 2643, 8022, 
6323, 2211, 2644
3302, 471, 126, 472, 702, 1919, 1921, 1923, 
6055, 5340, 5070
3303, 1024, 512, 174, 425, 8074, 2012, 4403, 
4433, 7148, 4401
3304, 864, 827, 472, 708, 3508, 5069, 5930, 
3507, 3440, 5178
3305, 473, 586, 599, 709, 2324, 2449, 2448, 
5581, 7894, 5580
3306, 1349, 797, 1136, 798, 5556, 7690, 7374, 
5453, 3363, 7375
3307, 1158, 741, 844, 833, 5823, 3632, 5303, 
6014, 3582, 3450
3308, 1024, 512, 513, 174, 8074, 2211, 6322, 
4403, 2012, 2013
3309, 700, 93, 1191, 246, 5055, 5058, 5056, 
2941, 2774, 7580
3310, 1286, 1072, 1075, 1063, 8115, 4615, 5079, 
6934, 4595, 4614
3311, 374, 804, 803, 1355, 3167, 3368, 3166, 
5127, 5364, 5117
3312, 832, 313, 277, 106, 3261, 2966, 3262, 
7105, 7306, 2903
3313, 1315, 92, 461, 574, 5686, 1878, 5687, 
6830, 2147, 2291
3314, 442, 1194, 1343, 1344, 7737, 6158, 6748, 
6747, 8094, 6397
3315, 1161, 286, 285, 836, 7996, 1613, 7383, 
7312, 3392, 3394
3316, 900, 922, 286, 285, 7566, 7501, 3780, 
3781, 5978, 1613
3317, 892, 908, 919, 901, 3812, 7348, 7760, 
3798, 3813, 5887
3318, 1351, 635, 553, 1353, 7158, 2445, 6753, 
6752, 7160, 6754
3319, 1219, 1221, 987, 976, 7534, 6154, 7353, 
7468, 6153, 4246
3320, 36, 1231, 417, 745, 5966, 7750, 1801, 
3046, 8020, 7299
3321, 835, 886, 1211, 740, 3725, 7021, 6200, 
3301, 3726, 5827
3322, 586, 709, 1209, 1157, 7894, 7453, 7471, 
6882, 6201, 7434
3323, 440, 553, 19, 208, 7085, 2094, 1832, 
4835, 2093, 1523
3324, 846, 864, 587, 707, 3536, 5929, 7994, 
3457, 3510, 5957
3325, 860, 1197, 792, 723, 7096, 6371, 3497, 
3520, 7652, 3494
3326, 1208, 842, 1207, 886, 6147, 6150, 6148, 
7510, 3730, 7963
3327, 471, 702, 470, 125, 6055, 6056, 1920, 
1918, 5341, 1917
3328, 1335, 544, 1122, 1334, 6269, 6615, 7769, 
5532, 6107, 5413
3329, 299, 1336, 654, 724, 6177, 6175, 6176, 
3002, 6889, 6796
3330, 680, 681, 1319, 242, 2766, 6034, 7153, 
2762, 2764, 6036
3331, 1117, 1331, 791, 1339, 7516, 7518, 7517, 
5245, 8053, 4957
3332, 1348, 1143, 1346, 1141, 5397, 5398, 5400, 
6316, 4213, 6391
3333, 1362, 266, 113, 583, 5170, 2885, 5172, 
6739, 6740, 2311
3334, 600, 846, 587, 707, 6487, 7994, 2629, 
4986, 3457, 5957
3335, 1348, 221, 1201, 865, 7654, 6224, 5634, 
5571, 6225, 5621
3336, 1362, 813, 1153, 812, 7236, 6765, 5723, 
6732, 3376, 6764
3337, 988, 501, 1241, 165, 8068, 6266, 5870, 
4260, 1990, 6267
3338, 823, 1279, 678, 239, 6348, 8057, 4993, 
3219, 6349, 2756
3339, 1071, 1280, 1286, 1281, 7856, 7677, 7826, 
6305, 8013, 7827
3340, 758, 757, 847, 1256, 3323, 3618, 3617, 
6941, 6816, 6942
3341, 754, 1011, 755, 333, 7221, 6221, 3320, 
3064, 4345, 3067
3342, 221, 249, 865, 685, 2716, 3518, 6225, 
2828, 2778, 7498
3343, 9, 493, 158, 33, 1974, 1973, 1463, 
1795, 7870, 4184
3344, 677, 1279, 697, 239, 5010, 4963, 5012, 
2754, 6349, 2935
3345, 1279, 677, 678, 239, 5010, 2758, 8057, 
6349, 2754, 2756
3346, 1348, 96, 221, 685, 7719, 2715, 7654, 
5590, 2826, 2828
3347, 278, 106, 150, 107, 2906, 1895, 7752, 
2905, 1403, 1896
3348, 1363, 1362, 811, 829, 5700, 5702, 5703, 
5334, 5171, 3660
3349, 742, 710, 743, 1214, 3307, 3306, 3305, 
6280, 6246, 6249
3350, 410, 894, 392, 920, 7881, 3763, 7514, 
3901, 7199, 7590
3351, 35, 1243, 740, 414, 5041, 6827, 3037, 
1797, 7722, 6468
3352, 412, 389, 411, 893, 8124, 7102, 1790, 
6235, 3758, 6454
3353, 1350, 551, 1353, 1140, 7821, 8092, 7794, 
7796, 8093, 5161
3354, 587, 846, 657, 878, 7994, 6981, 2659, 
8043, 3733, 7431
3355, 412, 389, 945, 411, 8124, 4030, 7044, 
1790, 7102, 8103
3356, 918, 911, 893, 894, 5758, 3832, 5759, 
6888, 3831, 3786
3357, 552, 551, 1353, 637, 2250, 8092, 7073, 
2470, 2451, 8095
3358, 1362, 812, 811, 829, 6732, 3375, 5702, 
