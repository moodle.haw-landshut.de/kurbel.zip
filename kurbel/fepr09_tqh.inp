5171, 3715, 3660
3359, 211, 1363, 1151, 556, 5092, 5463, 2714, 
2099, 7485, 7879
3360, 1338, 299, 937, 298, 6135, 6136, 5763, 
7621, 1627, 6676
3361, 703, 709, 473, 708, 3429, 5581, 5875, 
3428, 3267, 5180
3362, 412, 389, 388, 945, 8124, 1739, 6236, 
7044, 4030, 4029
3363, 1239, 329, 993, 994, 7571, 4275, 5804, 
8036, 4277, 4279
3364, 604, 1212, 1156, 1158, 7699, 6013, 5345, 
7494, 6015, 6011
3365, 284, 890, 917, 899, 3752, 5981, 6124, 
3778, 3800, 6125
3366, 478, 1308, 132, 590, 5446, 5224, 1936, 
2334, 7033, 2335
3367, 812, 1362, 811, 380, 6732, 5702, 3375, 
3184, 6898, 3183
3368, 116, 1354, 250, 701, 8037, 7923, 2851, 
8033, 5445, 2944
3369, 955, 969, 939, 970, 4110, 6086, 5236, 
4122, 4127, 6087
3370, 283, 1158, 844, 833, 5301, 5303, 3451, 
3269, 6014, 3450
3371, 937, 1333, 932, 131, 7269, 5222, 3987, 
3986, 7268, 3967
3372, 1237, 1166, 1234, 1164, 4920, 7804, 7709, 
7295, 6742, 7257
3373, 738, 491, 737, 733, 5856, 5854, 3294, 
3584, 6999, 3448
3374, 919, 289, 892, 288, 5863, 3755, 7760, 
8018, 1616, 3756
3375, 948, 937, 956, 297, 7206, 6678, 4072, 
4036, 6677, 4059
3376, 292, 413, 133, 291, 7310, 3962, 5247, 
1620, 4940, 8086
3377, 752, 1248, 851, 1249, 5925, 5924, 3469, 
6561, 6381, 7803
3378, 958, 408, 934, 933, 6761, 3973, 6762, 
6028, 3970, 3974
3379, 153, 736, 315, 737, 6508, 3028, 4174, 
6407, 3293, 3031
3380, 288, 482, 287, 916, 7546, 6242, 1615, 
7012, 6081, 6244
3381, 1215, 1156, 1158, 1216, 8125, 6011, 5820, 
8126, 5308, 7493
3382, 947, 295, 932, 955, 4034, 6572, 6448, 
4079, 4057, 5235
3383, 412, 389, 893, 388, 8124, 3758, 6235, 
6236, 1739, 3759
3384, 1254, 1252, 1170, 1253, 5538, 5539, 5540, 
7570, 7238, 6218
3385, 944, 412, 413, 387, 6350, 1791, 6352, 
4026, 7991, 4941
3386, 291, 944, 413, 387, 4028, 6352, 4940, 
4025, 4026, 4941
3387, 1129, 1332, 1116, 1331, 6735, 7792, 4814, 
7705, 5457, 8061
3388, 633, 654, 660, 1336, 2682, 2683, 2706, 
7563, 6175, 5947
3389, 664, 691, 1235, 817, 8127, 6493, 6501, 
5861, 3402, 6659
3390, 130, 299, 477, 476, 7614, 6137, 1933, 
1932, 6569, 2174
3391, 1002, 1167, 1004, 999, 6171, 6173, 4311, 
4305, 6464, 4310
3392, 713, 288, 289, 1252, 2979, 1616, 2980, 
7237, 7013, 7014
3393, 1174, 713, 289, 1252, 6564, 2980, 6566, 
7552, 7237, 7014
3394, 1194, 1197, 1341, 1337, 6621, 6370, 6159, 
6622, 6623, 6700
3395, 412, 893, 411, 923, 6235, 6454, 1790, 
3917, 5761, 3918
3396, 1293, 644, 518, 623, 6078, 2484, 6068, 
7922, 2486, 2419
3397, 592, 482, 1252, 916, 2361, 5254, 7350, 
4933, 6081, 7015
3398, 408, 933, 385, 407, 3970, 6029, 7107, 
1785, 3971, 5565
3399, 501, 988, 1233, 164, 8068, 7682, 7715, 
1989, 4261, 7693
3400, 797, 684, 248, 247, 7474, 2776, 3226, 
3227, 2775, 1568
3401, 1234, 1241, 1166, 1235, 7272, 5051, 7804, 
7274, 5898, 4923
3402, 914, 408, 385, 407, 3884, 7107, 5872, 
3883, 1785, 5565
3403, 1177, 655, 456, 623, 6437, 2616, 5213, 
7966, 2666, 2603
3404, 386, 406, 407, 935, 7129, 1784, 5564, 
7164, 3976, 3988
3405, 683, 1316, 699, 825, 5735, 6233, 7833, 
5241, 5714, 3386
3406, 698, 1190, 1320, 679, 7405, 8081, 7186, 
7066, 5286, 7889
3407, 1177, 456, 672, 570, 5213, 6667, 6666, 
6944, 2276, 7460
3408, 784, 681, 1108, 1318, 6033, 7088, 7054, 
4992, 7144, 7843
3409, 929, 945, 953, 411, 6232, 4053, 7143, 
3956, 8103, 5522
3410, 244, 683, 682, 699, 2770, 2772, 2768, 
2939, 7833, 6234
3411, 963, 967, 927, 961, 4129, 7019, 6684, 
4128, 4098, 5544
3412, 986, 1217, 1216, 1215, 6531, 6533, 6532, 
6281, 6413, 8126
3413, 1218, 980, 1217, 1216, 6522, 6534, 7410, 
7333, 5494, 6533
3414, 1228, 1220, 498, 1225, 6773, 5965, 7147, 
6771, 5672, 7151
3415, 1220, 885, 1162, 1222, 7946, 6516, 6774, 
7076, 7443, 7078
3416, 1219, 710, 743, 884, 6245, 3306, 6248, 
6529, 3727, 3678
3417, 652, 1241, 1233, 501, 5047, 5050, 5048, 
2563, 6266, 7715
3418, 977, 324, 744, 1219, 4205, 3045, 7958, 
7445, 7467, 6530
3419, 724, 723, 298, 1336, 3275, 3000, 3001, 
6889, 7624, 7622
3420, 980, 984, 972, 1217, 4234, 4233, 4224, 
6534, 5907, 7930
3421, 991, 1235, 992, 1003, 5169, 7537, 4273, 
4323, 5167, 4328
3422, 1237, 1166, 1235, 1234, 4920, 4923, 4921, 
7709, 7804, 7274
3423, 929, 412, 945, 411, 3957, 7044, 6232, 
3956, 1790, 8103
3424, 988, 501, 1233, 1241, 8068, 7715, 7682, 
5870, 6266, 5050
3425, 36, 1231, 1001, 417, 5966, 5967, 4265, 
1801, 7750, 4266
3426, 1304, 1087, 532, 1309, 7190, 7807, 7808, 
7191, 7189, 7835
3427, 1216, 980, 986, 971, 5494, 4242, 6532, 
5447, 4222, 4240
3428, 287, 922, 891, 919, 6243, 8007, 3753, 
8019, 3932, 5888
3429, 988, 419, 1000, 1233, 4291, 4297, 4313, 
7682, 6537, 7960
3430, 1164, 666, 818, 1166, 7712, 7891, 7132, 
6742, 7890, 4924
3431, 70, 71, 569, 664, 1366, 2134, 2133, 
2783, 2782, 6142
3432, 1015, 511, 425, 173, 7137, 7048, 4359, 
4360, 2009, 4335
3433, 1328, 296, 721, 875, 6373, 2996, 6861, 
7646, 3578, 3577
3434, 992, 1235, 1236, 1003, 7537, 6526, 7421, 
4328, 5167, 7130
3435, 632, 647, 631, 1198, 2600, 2599, 2598, 
5112, 5422, 5424
3436, 1172, 611, 1251, 593, 7837, 7572, 6857, 
7985, 2668, 7325
3437, 1260, 837, 1275, 1174, 5354, 5942, 5848, 
5356, 5352, 5342
3438, 127, 827, 473, 472, 7507, 5179, 1924, 
1922, 5069, 1926
3439, 517, 1033, 422, 1247, 5884, 4430, 5885, 
5982, 5582, 5584
3440, 1087, 1078, 532, 1309, 4658, 7863, 7807, 
7189, 6994, 7835
3441, 860, 724, 869, 1337, 3685, 3688, 3542, 
6701, 6601, 6699
3442, 880, 1176, 1173, 1174, 6553, 5577, 6554, 
6900, 5355, 6915
3443, 38, 423, 1256, 758, 1809, 6815, 8021, 
3073, 7790, 6941
3444, 425, 512, 174, 14, 7148, 2012, 4401, 
1812, 2011, 1482
3445, 1220, 658, 1223, 1222, 5974, 5973, 5692, 
7076, 7983, 7110
3446, 104, 706, 465, 275, 6382, 5596, 1891, 
2899, 2964, 5276
3447, 339, 1265, 1029, 761, 6138, 7576, 4417, 
3078, 6301, 6542
3448, 540, 1321, 1322, 573, 8038, 6690, 5619, 
2509, 5102, 6223
3449, 664, 691, 817, 224, 8127, 3402, 5861, 
2720, 2924, 3202
3450, 1309, 1091, 1082, 1094, 6993, 4673, 7521, 
7187, 4677, 4672
3451, 711, 866, 876, 1223, 3599, 3598, 3590, 
5694, 7111, 6769
3452, 422, 1169, 1018, 1006, 7315, 8003, 4368, 
4362, 7395, 4383
3453, 1006, 1169, 506, 422, 7395, 7397, 7399, 
4362, 7315, 7314
3454, 836, 1162, 884, 1161, 7331, 6517, 3741, 
7312, 7332, 7313
3455, 1186, 1091, 1309, 1307, 8088, 6993, 5031, 
5033, 6995, 5032
3456, 836, 1162, 885, 884, 7331, 6516, 3729, 
3741, 6517, 3692
3457, 108, 568, 107, 279, 2129, 2128, 1404, 
2907, 6277, 2908
3458, 295, 1333, 932, 296, 6376, 5222, 6572, 
1624, 6374, 6573
3459, 836, 1162, 1220, 885, 7331, 6774, 6794, 
3729, 6516, 7946
3460, 265, 112, 264, 839, 2883, 2882, 1589, 
3417, 8104, 3420
3461, 419, 500, 1233, 164, 6536, 6539, 6537, 
4259, 1988, 7693
3462, 229, 1265, 668, 1266, 6299, 6583, 2729, 
5795, 5189, 4954
3463, 1072, 771, 1280, 770, 6543, 7775, 8114, 
6544, 3336, 6932
3464, 636, 1205, 656, 1324, 6648, 5508, 2596, 
5518, 7977, 5517
3465, 1182, 1043, 1056, 1059, 4989, 4519, 6624, 
7822, 4534, 4533
3466, 1280, 1072, 429, 1062, 8114, 4550, 5882, 
7857, 4611, 4552
3467, 1304, 1303, 1305, 1294, 7597, 7596, 7599, 
7177, 7887, 7424
3468, 1046, 1057, 1181, 1059, 4541, 7834, 4979, 
4526, 4542, 4980
3469, 845, 720, 721, 1189, 3454, 3274, 3455, 
6103, 6683, 8076
3470, 1302, 1080, 1305, 777, 7993, 4915, 7883, 
7906, 7766, 7231
3471, 724, 723, 1336, 860, 3275, 7624, 6889, 
3685, 3520, 7696
3472, 792, 1119, 1341, 793, 6901, 5372, 5781, 
3358, 7098, 4996
3473, 618, 1179, 610, 519, 5715, 7729, 2498, 
2408, 6563, 2392
3474, 1043, 1180, 521, 520, 4987, 4972, 4988, 
6885, 7895, 2219
3475, 1324, 870, 1205, 1314, 6855, 8108, 7977, 
5429, 7586, 5506
3476, 251, 816, 252, 117, 3195, 3194, 1575, 
2853, 7491, 2856
3477, 199, 1112, 200, 543, 4761, 4760, 1513, 
2073, 7367, 2074
3478, 1182, 1043, 1059, 1180, 4989, 4534, 7822, 
4973, 4987, 4977
3479, 46, 801, 1354, 701, 3159, 6652, 6653, 
3161, 3366, 5445
3480, 830, 266, 583, 114, 3249, 6740, 5877, 
5853, 2886, 2305
3481, 1263, 761, 1029, 668, 7476, 6542, 6480, 
5262, 6584, 6481
3482, 77, 1263, 514, 668, 5528, 6656, 2475, 
2792, 5262, 7740
3483, 430, 1280, 1278, 429, 7855, 5880, 5740, 
1818, 5882, 5878
3484, 1265, 229, 693, 1266, 6299, 2927, 6300, 
5189, 5795, 5136
3485, 881, 1171, 1265, 1266, 4956, 7736, 5952, 
4955, 4906, 5189
3486, 881, 1265, 693, 1266, 5952, 6300, 3621, 
4955, 5189, 5136
3487, 681, 243, 784, 242, 2765, 3222, 6033, 
2764, 1563, 3223
3488, 1247, 1268, 517, 1033, 6555, 5654, 5982, 
5582, 7122, 5884
3489, 1320, 1101, 1102, 360, 5414, 4711, 5034, 
7481, 4706, 4708
3490, 823, 1279, 1300, 678, 6348, 8055, 7559, 
4993, 8057, 8056
3491, 785, 1101, 1100, 1319, 8008, 4707, 7619, 
7508, 5417, 7055
3492, 351, 1302, 1080, 1090, 8025, 7993, 4626, 
4657, 5731, 4661
3493, 1061, 1284, 1069, 1073, 5747, 6574, 4581, 
4590, 7483, 4591
3494, 1313, 1310, 856, 1189, 5229, 6715, 6687, 
5614, 5616, 6101
3495, 430, 1280, 1071, 1281, 7855, 7856, 4586, 
7774, 8013, 6305
3496, 1112, 1127, 1122, 1334, 4819, 4824, 4799, 
7368, 5411, 5413
3497, 507, 170, 1006, 169, 2002, 4331, 7398, 
2001, 1477, 4332
3498, 586, 709, 1157, 1212, 7894, 6201, 6882, 
6971, 5710, 6062
3499, 86, 1279, 677, 678, 7632, 5010, 2810, 
2813, 8057, 2758
3500, 1091, 1307, 1088, 1078, 6995, 5272, 4662, 
4663, 5439, 4659
3501, 49, 898, 63, 55, 3774, 5369, 3846, 
1747, 6923, 1758
3502, 777, 1302, 1294, 1305, 7906, 7798, 6673, 
7231, 7883, 7424
3503, 719, 1309, 1305, 1187, 7523, 7520, 5644, 
6475, 7346, 7249
3504, 1253, 1174, 1255, 1254, 6963, 6633, 7601, 
7570, 6643, 5904
3505, 1090, 1079, 432, 1297, 4682, 4625, 4623, 
5336, 7858, 5339
3506, 598, 633, 634, 1337, 2681, 2550, 2551, 
6603, 6738, 6402
3507, 1291, 1177, 1270, 1292, 4899, 4901, 4900, 
6426, 6427, 7245
3508, 944, 292, 930, 946, 4031, 5249, 6351, 
4087, 4033, 7086
3509, 698, 786, 1320, 787, 3511, 6802, 7186, 
3512, 3352, 7482
3510, 1190, 787, 823, 698, 7541, 3655, 7406, 
7405, 3512, 3379
3511, 548, 584, 1347, 549, 2310, 6449, 7157, 
2247, 2308, 6627
3512, 1094, 1092, 1305, 1304, 4686, 7420, 7422, 
7188, 7598, 7599
3513, 669, 694, 231, 670, 5682, 2929, 2733, 
2737, 5684, 2735
3514, 858, 1324, 870, 1205, 6854, 6855, 3548, 
7976, 7977, 8108
3515, 1174, 1253, 1255, 1173, 6963, 7601, 6633, 
6915, 7216, 7602
3516, 1120, 1197, 1128, 1118, 7721, 7734, 4812, 
4818, 6367, 4827
3517, 207, 552, 1140, 208, 2091, 7074, 4863, 
1522, 2092, 4862
3518, 1077, 1304, 190, 531, 7828, 7806, 4617, 
6354, 7179, 2050
3519, 266, 113, 583, 114, 2885, 2311, 6740, 
2886, 1411, 2305
3520, 372, 1354, 701, 46, 6212, 5445, 3162, 
1716, 6653, 3161
3521, 870, 863, 1205, 845, 3549, 8023, 8108, 
3707, 3601, 8109
3522, 1146, 1131, 1350, 1140, 4718, 8128, 7795, 
4712, 4853, 7796
3523, 867, 852, 1278, 1279, 3708, 7907, 8129, 
7213, 4960, 5200
3524, 200, 1112, 1122, 1334, 4760, 4799, 4793, 
7366, 7368, 5413
3525, 1357, 566, 565, 219, 5066, 2267, 5408, 
5392, 2124, 2121
3526, 457, 676, 84, 85, 6838, 2809, 1868, 
1869, 2808, 1380
3527, 20, 203, 443, 1342, 1517, 4764, 1836, 
7901, 7647, 7732
3528, 1154, 813, 382, 381, 7509, 3187, 2374, 
2269, 3186, 1728
3529, 1342, 20, 548, 443, 7901, 2083, 5509, 
7732, 1836, 7212
3530, 940, 966, 968, 949, 7260, 4124, 5183, 
5182, 4096, 4102
3531, 603, 507, 1169, 506, 2378, 7396, 7403, 
2377, 2205, 7397
3532, 1349, 797, 1350, 1136, 5556, 5558, 5557, 
7374, 7690, 7692
3533, 814, 445, 1154, 382, 5295, 2373, 5637, 
3188, 2372, 2374
3534, 584, 1201, 1347, 580, 5208, 5631, 6449, 
2309, 6697, 7092
3535, 551, 684, 1202, 1350, 8102, 7816, 5791, 
7821, 7475, 7817
3536, 1146, 1135, 1136, 1350, 4138, 4848, 4134, 
7795, 7691, 7692
3537, 791, 792, 1339, 723, 3357, 4959, 4957, 
3495, 3494, 6048
3538, 1116, 1127, 1115, 1332, 4828, 4823, 4773, 
7792, 7708, 7874
3539, 1223, 1249, 711, 851, 7193, 7192, 5694, 
7329, 7803, 3612
3540, 9, 33, 734, 1355, 1795, 3025, 6409, 
7114, 8097, 6851
3541, 366, 1346, 1132, 1345, 6610, 6326, 4864, 
7309, 6730, 7211
3542, 838, 1349, 1350, 1203, 5454, 5557, 5393, 
5921, 6755, 6724
3543, 764, 850, 854, 1273, 3466, 3546, 3477, 
6155, 5015, 6274
3544, 602, 1208, 1157, 586, 6845, 6848, 6846, 
2652, 8107, 6882
3545, 549, 1347, 1130, 1348, 6627, 5124, 6628, 
6913, 5632, 6317
3546, 1044, 1271, 1273, 1178, 7763, 5018, 7764, 
7948, 5159, 8080
3547, 189, 1077, 190, 531, 4618, 4617, 1501, 
2049, 6354, 2050
3548, 1312, 1311, 1093, 1091, 7342, 7830, 7623, 
7626, 7364, 4668
3549, 855, 1310, 1312, 1186, 6578, 6580, 6581, 
6841, 6716, 7343
3550, 1160, 606, 1218, 605, 6546, 7454, 7411, 
6144, 2514, 7455
3551, 1307, 1091, 1311, 1186, 6995, 7364, 5269, 
5033, 8088, 5278
3552, 1215, 742, 975, 1214, 6279, 7724, 6524, 
6197, 6280, 7716
3553, 86, 677, 458, 85, 2810, 7174, 1871, 
1381, 2811, 1870
3554, 603, 1168, 507, 642, 7638, 7279, 2378, 
2479, 7340, 2477
3555, 1241, 988, 165, 998, 5870, 4260, 6267, 
5871, 4299, 4293
3556, 695, 232, 1175, 671, 2932, 5985, 5986, 
5132, 2738, 6204
3557, 1195, 296, 1192, 722, 7988, 8119, 7426, 
7379, 2997, 7425
3558, 1077, 1304, 531, 1303, 7828, 7179, 6354, 
6357, 7597, 6355
3559, 672, 456, 673, 81, 6667, 5215, 2839, 
2800, 1866, 2803
3560, 1259, 80, 455, 570, 5816, 1864, 5817, 
6945, 2137, 2167
3561, 820, 694, 670, 231, 3382, 5684, 6496, 
3211, 2929, 2735
3562, 1305, 1094, 1082, 1081, 7422, 4672, 6106, 
4916, 4671, 4633
3563, 1332, 790, 722, 875, 5455, 3634, 5458, 
5436, 3637, 3636
3564, 427, 1178, 1044, 1054, 8113, 7948, 4480, 
4511, 7949, 4516
3565, 1116, 1117, 1331, 363, 4776, 7516, 8061, 
4772, 4774, 7519
3566, 1312, 1311, 1310, 1093, 7342, 5615, 6580, 
7623, 7830, 5231
3567, 1095, 537, 195, 194, 6721, 2062, 4688, 
4689, 2061, 1507
3568, 1276, 1277, 30, 1180, 6779, 7393, 6595, 
5513, 7319, 6938
3569, 738, 154, 492, 815, 6435, 1970, 6066, 
3304, 6436, 6065
3570, 43, 1327, 799, 788, 7068, 5381, 3154, 
3133, 6702, 3353
3571, 826, 815, 733, 492, 3237, 3529, 3389, 
6462, 6065, 6067
3572, 1186, 1091, 1082, 1309, 8088, 4673, 7777, 
5031, 6993, 7521
3573, 1276, 1277, 481, 30, 6779, 5137, 6593, 
6595, 7393, 6592
3574, 551, 684, 1350, 94, 8102, 7475, 7821, 
2149, 2825, 7820
3575, 1316, 882, 699, 825, 7543, 3631, 6233, 
5714, 3656, 3386
3576, 764, 765, 1273, 854, 3330, 7745, 6155, 
3477, 3476, 6274
3577, 797, 247, 838, 1350, 3227, 3410, 3409, 
5558, 5395, 5393
3578, 973, 1210, 982, 415, 5792, 5793, 4232, 
4195, 5497, 4229
3579, 1168, 1021, 1248, 1018, 5739, 6378, 7982, 
7470, 4378, 7069
3580, 531, 595, 1304, 532, 2422, 7178, 7179, 
2230, 2423, 7808
3581, 416, 1246, 168, 997, 4885, 5808, 4264, 
4288, 5810, 4289
3582, 1208, 474, 586, 609, 8067, 2331, 8107, 
6227, 2462, 2461
3583, 258, 259, 125, 732, 1582, 2877, 2876, 
3201, 3239, 6061
3584, 986, 1210, 973, 983, 5794, 5792, 4253, 
4258, 5825, 4254
3585, 997, 996, 415, 1245, 4290, 4285, 4287, 
7439, 7967, 7713
3586, 1189, 656, 1314, 627, 5699, 5507, 5698, 
5768, 2597, 5754
3587, 422, 1169, 1247, 1018, 7315, 6639, 5584, 
4368, 8003, 7688
3588, 1226, 977, 744, 1162, 7939, 7958, 6777, 
6778, 7419, 6518
3589, 984, 1215, 975, 1214, 6414, 6524, 4243, 
5909, 6197, 7716
3590, 643, 1279, 579, 572, 8005, 5202, 2530, 
2531, 7633, 2286
3591, 622, 1281, 523, 524, 7772, 5487, 2416, 
2417, 8054, 2222
3592, 977, 1219, 744, 1162, 7445, 6530, 7958, 
7419, 6528, 6518
3593, 1218, 496, 1216, 605, 6521, 5578, 7333, 
7455, 2381, 6146
3594, 1218, 980, 972, 1217, 6522, 4224, 7118, 
7410, 6534, 7930
3595, 1221, 1160, 1161, 1218, 7412, 6548, 7417, 
7409, 7411, 8091
3596, 1160, 606, 1161, 1218, 6546, 5673, 6548, 
7411, 7454, 8091
3597, 988, 1234, 1233, 1000, 7681, 7256, 7682, 
4313, 7962, 7960
3598, 1216, 1215, 1160, 1158, 8126, 6191, 6143, 
7493, 5820, 5302
3599, 1232, 1231, 1163, 418, 7955, 5894, 7989, 
7196, 7751, 7201
3600, 1228, 607, 499, 498, 7146, 2386, 8082, 
7147, 2385, 2197
3601, 985, 418, 979, 1229, 4237, 4215, 4235, 
7254, 7888, 7185
3602, 1068, 188, 1293, 428, 4574, 8014, 5999, 
4573, 4548, 5628
3603, 1164, 746, 848, 1231, 7294, 3460, 7131, 
7171, 5968, 5891
3604, 1165, 687, 73, 451, 7291, 2834, 7307, 
6333, 7882, 1852
3605, 922, 900, 890, 285, 7566, 3796, 5979, 
5978, 3781, 3751
3606, 879, 885, 876, 1222, 3694, 3728, 3716, 
7059, 7443, 6866
3607, 658, 603, 1223, 662, 2624, 7859, 5973, 
2676, 2663, 6640
3608, 1208, 474, 1155, 1209, 8067, 6903, 6149, 
7435, 7925, 7975
3609, 745, 978, 325, 1226, 7301, 4208, 3047, 
7330, 7267, 7762
3610, 1291, 1074, 1270, 1067, 7391, 7914, 4900, 
4878, 4605, 7910
3611, 1229, 978, 1226, 985, 7265, 7267, 7252, 
7254, 4248, 7253
3612, 1328, 1314, 845, 1189, 5503, 6104, 8101, 
5475, 5698, 6103
3613, 1276, 520, 619, 1180, 7578, 2410, 6635, 
5513, 7895, 4971
3614, 300, 476, 931, 129, 6568, 6571, 6163, 
6162, 1931, 3965
3615, 787, 823, 853, 1295, 3655, 3650, 3475, 
6921, 7542, 8121
3616, 225, 665, 691, 1166, 2722, 8050, 2923, 
7892, 7219, 7943
3617, 896, 914, 905, 889, 6982, 6835, 3804, 
3802, 7440, 3803
3618, 1215, 1156, 1211, 1158, 8125, 5834, 5819, 
5820, 6011, 5821
3619, 793, 441, 1345, 44, 4994, 4997, 4995, 
3142, 1833, 7469
3620, 664, 691, 224, 665, 8127, 2924, 2720, 
2723, 8050, 2721
3621, 1328, 1314, 1205, 845, 5503, 5506, 5504, 
8101, 6104, 8109
3622, 604, 484, 1160, 605, 2684, 7121, 6145, 
2534, 2576, 6144
3623, 506, 517, 422, 616, 2216, 5885, 7314, 
2405, 2404, 7316
3624, 1248, 420, 1019, 752, 6972, 4337, 6379, 
5925, 6974, 6560
3625, 1264, 512, 1261, 454, 8073, 6832, 6897, 
8022, 2643, 6833
3626, 508, 171, 1007, 1016, 2004, 4334, 6871, 
7280, 4363, 4372
3627, 1025, 176, 1034, 514, 4405, 4434, 4443, 
7739, 2016, 6276
3628, 1320, 786, 360, 787, 6802, 3128, 7481, 
7482, 3352, 3131
3629, 999, 504, 168, 167, 7321, 1996, 4294, 
4295, 1995, 1474
3630, 1215, 984, 975, 986, 6414, 4243, 6524, 
6281, 4255, 4256
3631, 490, 1357, 734, 868, 5122, 6852, 6410, 
5123, 5068, 3539
3632, 423, 1258, 1256, 758, 6814, 5389, 6815, 
7790, 6939, 6941
3633, 1300, 1190, 678, 572, 7226, 7637, 8056, 
7227, 7229, 8058
3634, 332, 1010, 873, 754, 4342, 7017, 3318, 
3065, 7634, 3319
3635, 1022, 1254, 1020, 1253, 7591, 7031, 4390, 
7214, 7570, 7575
3636, 410, 392, 393, 920, 7514, 3858, 3895, 
3901, 7590, 3902
3637, 343, 1046, 767, 1047, 4485, 7974, 3091, 
4487, 4489, 7897
3638, 768, 1182, 1047, 767, 6618, 7616, 8065, 
3333, 6617, 7897
3639, 150, 106, 312, 151, 1895, 8096, 4166, 
1454, 2312, 4168
3640, 757, 38, 1256, 758, 3070, 8021, 6816, 
3323, 3073, 6941
3641, 1300, 1190, 823, 678, 7226, 7406, 7559, 
8056, 7637, 4993
3642, 615, 1257, 1260, 614, 7998, 7997, 7902, 
2488, 6904, 8077
3643, 1011, 1170, 1020, 1023, 6219, 7564, 4386, 
4385, 7565, 4391
3644, 820, 1258, 758, 847, 6862, 6939, 3654, 
3459, 6940, 3617
3645, 835, 741, 1211, 833, 3302, 5822, 6200, 
3583, 3582, 6052
3646, 343, 1047, 767, 344, 4487, 7897, 3091, 
1681, 4488, 3090
3647, 1296, 859, 853, 1298, 5203, 3581, 5217, 
7628, 6022, 6024
3648, 1171, 881, 1265, 763, 4956, 5952, 7736, 
8059, 3619, 5953
3649, 1156, 986, 1210, 1213, 5832, 5794, 5833, 
5307, 8112, 7927
3650, 351, 1302, 777, 1080, 8025, 7906, 3111, 
4626, 7993, 7766
3651, 351, 1302, 776, 777, 8025, 5733, 3108, 
3111, 7906, 3342
3652, 823, 1300, 853, 1295, 7559, 7560, 3650, 
7542, 5349, 8121
3653, 40, 769, 429, 1049, 3094, 5881, 1817, 
4494, 6881, 4495
3654, 772, 237, 1286, 822, 3214, 6600, 6935, 
3407, 3217, 5107
3655, 420, 1032, 763, 1247, 4426, 6239, 6856, 
6973, 7000, 6790
3656, 1329, 1328, 1205, 1193, 5725, 5504, 6647, 
5727, 5729, 7785
3657, 299, 130, 931, 476, 7614, 3964, 6570, 
6569, 1932, 6571
3658, 1190, 787, 698, 1320, 7541, 3512, 7405, 
8081, 7482, 7186
3659, 1174, 1274, 289, 714, 5343, 7553, 6566, 
6565, 5567, 2981
3660, 1032, 1268, 1265, 1171, 5638, 5190, 5639, 
7723, 5657, 7736
3661, 837, 1259, 1269, 821, 6960, 6947, 5943, 
3404, 6167, 7548
3662, 1275, 1272, 644, 610, 4890, 6079, 5850, 
4928, 7730, 2485
3663, 140, 728, 302, 274, 5697, 3009, 4144, 
8098, 3197, 3011
3664, 1329, 1328, 624, 1205, 5725, 7362, 6646, 
6647, 5504, 6649
3665, 32, 144, 731, 306, 4154, 6428, 3018, 
1636, 4156, 3017
3666, 624, 1334, 630, 1328, 8130, 5530, 2589, 
7362, 5728, 7361
3667, 1074, 1291, 1270, 1292, 7391, 4900, 7914, 
7389, 6426, 7245
3668, 1058, 1182, 1048, 1183, 6625, 7617, 4540, 
8085, 5062, 7142
3669, 618, 638, 1276, 481, 2557, 8001, 6636, 
2556, 2457, 6593
3670, 1105, 540, 1322, 198, 8039, 5619, 7495, 
4725, 2068, 5620
3671, 771, 871, 1280, 770, 3565, 7678, 7775, 
3336, 3553, 6932
3672, 769, 1299, 867, 1278, 5005, 5206, 3564, 
5879, 5197, 8129
3673, 123, 258, 124, 146, 2868, 2867, 1422, 
1962, 7113, 2132
3674, 867, 852, 769, 1278, 3708, 3471, 3564, 
8129, 7907, 5879
3675, 769, 1299, 717, 867, 5005, 5007, 3563, 
3564, 5206, 3561
3676, 258, 145, 124, 146, 6411, 2183, 2867, 
7113, 1448, 2132
3677, 1076, 1065, 1066, 1288, 4603, 4563, 4602, 
7673, 7756, 7759
3678, 1061, 527, 186, 1283, 5918, 2041, 4547, 
5746, 5917, 5472
3679, 897, 892, 919, 289, 3788, 7760, 4945, 
3777, 3755, 5863
3680, 773, 1066, 1288, 774, 7758, 7759, 6663, 
3339, 7584, 6665
3681, 1259, 1177, 1269, 821, 6948, 6946, 6947, 
6167, 7606, 7548
3682, 185, 1069, 526, 1287, 4578, 5077, 2039, 
8078, 6306, 7335
3683, 1329, 542, 624, 543, 6705, 2420, 6646, 
8100, 2241, 2421
3684, 772, 236, 1282, 237, 3215, 7369, 7026, 
3214, 1557, 6599
3685, 186, 526, 1283, 527, 2040, 5473, 5472, 
2041, 2225, 5917
3686, 769, 40, 345, 1049, 3094, 1683, 3095, 
6881, 4494, 4493
3687, 1312, 779, 780, 855, 7225, 3345, 6582, 
6581, 3483, 3482
3688, 595, 650, 1294, 1188, 2537, 7169, 7168, 
7583, 6114, 6607
3689, 595, 1294, 1304, 1187, 7168, 7177, 7178, 
7345, 6604, 7885
3690, 1289, 527, 571, 1290, 7964, 2620, 7965, 
8084, 5916, 7603
3691, 1079, 1090, 1302, 1297, 4682, 5731, 7303, 
7858, 5336, 5732
3692, 617, 530, 531, 1303, 2406, 2229, 2407, 
7952, 6358, 6355
3693, 1191, 1327, 858, 1352, 8131, 7668, 6840, 
7042, 5383, 7669
3694, 210, 23, 555, 1361, 1526, 2098, 2097, 
7112, 6760, 8117
3695, 530, 434, 1077, 1301, 8004, 4648, 6356, 
7749, 7747, 6359
3696, 853, 776, 1297, 1298, 3474, 5338, 7630, 
6024, 6023, 7631
3697, 648, 650, 1299, 659, 2539, 6117, 6118, 
2679, 2673, 7540
3698, 534, 1307, 626, 533, 5266, 5268, 2427, 
2232, 7868, 2426
3699, 1343, 1199, 1337, 1341, 6399, 7097, 6892, 
6160, 8030, 6700
3700, 1328, 845, 721, 1189, 8101, 3455, 6861, 
5475, 6103, 8076
3701, 460, 537, 538, 1318, 2403, 2236, 2304, 
5936, 6720, 6338
3702, 556, 1363, 557, 211, 7485, 8120, 2258, 
2099, 5092, 2102
3703, 1328, 1308, 1189, 295, 5474, 5477, 5475, 
6375, 6682, 6681
3704, 1191, 1327, 1352, 1325, 8131, 5383, 7042, 
7041, 5777, 7008
3705, 624, 1334, 543, 630, 8130, 6108, 2421, 
2589, 5530, 2434
3706, 135, 286, 922, 483, 7499, 7501, 3913, 
1945, 7995, 7932
3707, 1324, 1314, 1205, 656, 5429, 5506, 7977, 
5517, 5507, 5508
3708, 627, 656, 651, 1189, 2597, 2707, 2559, 
5768, 5699, 6674
3709, 1158, 484, 1212, 283, 7697, 7698, 6015, 
5301, 5561, 8071
3710, 574, 1324, 1315, 700, 5516, 5431, 6830, 
5057, 6693, 6692
3711, 87, 1190, 459, 572, 7636, 5288, 1873, 
2144, 7229, 2277
3712, 1271, 1067, 1291, 1270, 4875, 4878, 4876, 
4903, 7910, 4900
3713, 1334, 1329, 624, 543, 5726, 6646, 8130, 
6108, 8100, 2421
3714, 452, 1268, 1266, 1267, 8099, 5191, 4952, 
4948, 5188, 4949
3715, 643, 1279, 572, 1300, 8005, 7633, 2531, 
6392, 8055, 7227
3716, 1288, 1289, 1185, 1290, 7755, 7754, 5753, 
5749, 8084, 5750
3717, 1357, 490, 1355, 565, 5122, 6850, 5365, 
5408, 2370, 5407
3718, 1138, 1351, 439, 1196, 6749, 5376, 4854, 
7037, 7038, 7515
3719, 1295, 1297, 1296, 853, 6919, 7629, 5348, 
8121, 7630, 5217
3720, 1300, 1190, 1295, 823, 7226, 7228, 5349, 
7559, 7406, 7542
3721, 1255, 511, 1015, 173, 6183, 7137, 7138, 
7738, 2009, 4360
3722, 263, 556, 810, 264, 7849, 7487, 3419, 
1588, 7852, 3418
3723, 252, 253, 118, 319, 1576, 2858, 2855, 
2946, 2945, 7848
3724, 1191, 1351, 553, 1196, 7040, 6753, 7277, 
7275, 7038, 7039
3725, 1329, 440, 1112, 1124, 6704, 4791, 7051, 
5020, 4797, 4813
3726, 199, 1329, 1112, 543, 7050, 7051, 4761, 
2073, 8100, 7367
3727, 544, 200, 1122, 1334, 2075, 4793, 6615, 
6107, 7366, 5413
3728, 1308, 1333, 932, 295, 5223, 5222, 5225, 
6682, 6376, 6572
3729, 550, 1130, 205, 1139, 6912, 4831, 2087, 
5787, 4859, 4858
3730, 1289, 571, 1185, 1290, 7965, 7613, 7754, 
8084, 7603, 5750
3731, 1328, 296, 1192, 1333, 6373, 8119, 7706, 
6377, 6374, 7878
3732, 544, 1335, 1122, 201, 6269, 7769, 6615, 
2076, 7768, 4792
3733, 1338, 654, 660, 477, 6174, 2683, 5292, 
5291, 2573, 2637
3734, 1342, 548, 1344, 443, 5509, 8000, 6403, 
7732, 7212, 6020
3735, 801, 4, 1204, 576, 5664, 5667, 5665, 
7247, 2322, 8123
3736, 364, 1117, 791, 1339, 4775, 7517, 3138, 
4958, 5245, 4957
3737, 724, 269, 704, 463, 3557, 2957, 3718, 
5865, 6213, 5867
3738, 556, 264, 111, 839, 7852, 2890, 2316, 
7488, 3420, 8105
3739, 1360, 1358, 109, 280, 6179, 6134, 6803, 
5844, 6178, 2909
3740, 1200, 443, 1347, 1141, 6017, 5125, 6018, 
7557, 4867, 5126
3741, 262, 703, 1209, 128, 2955, 7979, 7981, 
2874, 7978, 7472
3742, 937, 1333, 297, 932, 7269, 6099, 6677, 
3987, 5222, 7466
3743, 155, 492, 154, 815, 2483, 1970, 1459, 
6415, 6065, 6436
3744, 1143, 1132, 1346, 1141, 4218, 6326, 5398, 
4213, 4219, 6391
3745, 416, 1246, 494, 11, 4885, 4936, 7924, 
1800, 7904, 1975
3746, 1200, 1132, 1141, 1346, 7210, 4219, 7557, 
6950, 6326, 6391
3747, 1265, 340, 1030, 1031, 6139, 4420, 6140, 
6211, 4422, 4425
3748, 1259, 672, 1177, 821, 6679, 6666, 6948, 
6167, 6680, 7606
3749, 1204, 371, 445, 45, 5648, 4004, 5299, 
5647, 1714, 1839
3750, 309, 122, 257, 256, 7941, 2866, 2951, 
2952, 2863, 1580
3751, 1259, 837, 695, 821, 6960, 3405, 5131, 
6167, 3404, 3383
3752, 416, 1246, 11, 168, 4885, 7904, 1800, 
4264, 5808, 1475
3753, 714, 837, 1275, 854, 3431, 5942, 5569, 
3671, 3670, 5570
3754, 1202, 1146, 1131, 1350, 8122, 4718, 5785, 
7817, 7795, 8128
3755, 1131, 551, 1202, 1350, 5790, 5791, 5785, 
8128, 7821, 7817
3756, 1202, 1146, 1142, 1131, 8122, 4137, 5589, 
5785, 4718, 4719
3757, 1202, 1146, 1135, 1142, 8122, 4138, 6076, 
5589, 4137, 4139
3758, 1277, 1180, 716, 30, 7319, 6685, 6662, 
7393, 6938, 2985
3759, 739, 1356, 803, 1355, 6291, 5118, 3646, 
8070, 5119, 5117
3760, 1360, 109, 561, 3, 6803, 2159, 6804, 
6127, 1406, 2160
3761, 739, 493, 1355, 33, 7871, 6806, 8070, 
3034, 7870, 8097
3762, 149, 311, 734, 33, 4175, 3024, 6408, 
4165, 1642, 3025
3763, 463, 269, 462, 97, 6213, 6214, 1884, 
1882, 2892, 1881
3764, 128, 703, 127, 261, 7978, 7506, 1426, 
2871, 2956, 2872
3765, 1204, 576, 554, 209, 8123, 2274, 7166, 
6798, 2256, 2095
3766, 1242, 1167, 994, 1243, 7973, 6172, 7387, 
8012, 7448, 6853
3767, 1158, 484, 1160, 604, 7697, 7121, 5302, 
7494, 2684, 6145
3768, 890, 925, 917, 899, 6442, 3933, 5981, 
3800, 6261, 6125
3769, 996, 1242, 1243, 1245, 7385, 8012, 7959, 
7967, 7530, 7968
3770, 904, 918, 920, 894, 7608, 3904, 7198, 
3822, 6888, 7199
3771, 711, 1223, 851, 866, 5694, 7329, 3612, 
3599, 7111, 3627
3772, 391, 56, 394, 920, 6298, 3919, 3860, 
7197, 3924, 3903
3773, 391, 894, 920, 392, 3762, 7199, 7197, 
1743, 3763, 7590
3774, 464, 831, 730, 594, 4965, 3415, 6991, 
2501, 7011, 7109
3775, 409, 475, 5, 486, 8066, 1929, 1787, 
6821, 2179, 1952
3776, 163, 981, 498, 162, 4225, 7150, 1984, 
1468, 4226, 1983
3777, 575, 725, 463, 270, 7242, 7241, 2505, 
7865, 3254, 7864
3778, 1215, 1158, 741, 844, 5820, 5823, 5799, 
6192, 5303, 3632
3779, 1354, 801, 1204, 576, 6652, 5665, 6799, 
7075, 7247, 8123
3780, 1257, 1255, 1173, 1174, 6906, 7602, 5218, 
6905, 6633, 6915
3781, 948, 940, 968, 956, 5874, 5183, 4101, 
4072, 5181, 4100
3782, 128, 703, 473, 127, 7978, 5875, 1925, 
1426, 7506, 1924
3783, 1293, 644, 1272, 518, 6078, 6079, 6008, 
6068, 2484, 6069
3784, 618, 1179, 1274, 610, 5715, 5717, 5716, 
2498, 7729, 4929
3785, 125, 732, 259, 702, 6061, 3239, 2877, 
5341, 3414, 2954
3786, 1055, 764, 1273, 1271, 7533, 6155, 7600, 
7765, 4893, 5018
3787, 456, 82, 673, 81, 1867, 2802, 5215, 
1866, 1377, 2803
3788, 487, 101, 729, 272, 2131, 6469, 5625, 
5624, 2893, 3259
3789, 361, 1125, 1330, 1115, 4800, 6559, 7035, 
4769, 4804, 7934
3790, 149, 735, 312, 150, 7675, 3026, 4167, 
1453, 7725, 4166
3791, 209, 371, 445, 1204, 4005, 4004, 4003, 
6798, 5648, 5299
3792, 361, 788, 789, 1330, 3132, 3354, 3135, 
7035, 7036, 7935
3793, 1229, 419, 418, 979, 7940, 1803, 7888, 
7185, 4216, 4215
3794, 1362, 813, 558, 1153, 7236, 6718, 7990, 
5723, 6765, 7234
3795, 1219, 1161, 710, 884, 7938, 7311, 6245, 
6529, 7313, 3727
3796, 1227, 607, 1222, 578, 6911, 7167, 6864, 
7009, 2627, 6989
3797, 1179, 765, 1273, 1045, 7744, 7745, 6273, 
6878, 7893, 6877
3798, 900, 925, 890, 906, 6470, 6442, 3796, 
3805, 8069, 3806
3799, 903, 54, 912, 895, 3792, 7556, 5554, 
3791, 3765, 7326
3800, 493, 1356, 563, 468, 6805, 5789, 2545, 
2192, 8111, 2544
3801, 1154, 559, 558, 213, 7661, 2261, 7235, 
2702, 2106, 2103
3802, 886, 1210, 1211, 740, 7020, 5828, 7021, 
3726, 5826, 5827
3803, 265, 1363, 839, 829, 5331, 7486, 3417, 
3247, 5334, 3416
3804, 560, 445, 1204, 21, 5298, 5299, 5300, 
2107, 1840, 7165
3805, 839, 1363, 811, 829, 7486, 5703, 3661, 
3416, 5334, 3660
3806, 1179, 1044, 1057, 1273, 7947, 4521, 6876, 
6273, 7764, 6875
3807, 926, 903, 912, 895, 5553, 5554, 3941, 
4897, 3791, 7326
3808, 639, 1328, 649, 1333, 5476, 7363, 2546, 
7933, 6377, 5421
3809, 489, 471, 657, 878, 2571, 2612, 2611, 
7328, 6278, 7431
3810, 71, 665, 72, 449, 2785, 2784, 1367, 
1847, 8048, 1848
3811, 886, 835, 1211, 833, 3725, 6200, 7021, 
3735, 3583, 6052
3812, 1362, 113, 466, 583, 5172, 1901, 5951, 
6739, 2311, 2314
3813, 925, 926, 910, 923, 3946, 6271, 6585, 
3931, 3944, 6587
3814, 240, 698, 241, 679, 2938, 2937, 1561, 
2759, 7066, 2760
3815, 867, 1296, 1279, 1299, 5205, 8060, 7213, 
5206, 5207, 5198
3816, 1294, 717, 1299, 859, 7720, 5007, 6287, 
6671, 3528, 5204
3817, 383, 887, 888, 913, 3744, 3834, 3795, 
5609, 5830, 5607
3818, 1094, 1304, 1305, 1309, 7188, 7599, 7422, 
7187, 7191, 7520
3819, 550, 1130, 549, 205, 6912, 6628, 2248, 
2087, 4831, 2086
3820, 157, 119, 253, 118, 1908, 2857, 6059, 
1907, 1417, 2858
3821, 1025, 515, 176, 514, 6295, 2017, 4405, 
7739, 2213, 2016
3822, 27, 560, 1204, 4, 6717, 5300, 5666, 
1572, 2166, 5667
3823, 1359, 808, 1360, 1361, 5466, 6133, 7791, 
5470, 5467, 6130
3824, 1235, 1236, 817, 748, 6526, 6651, 6659, 
6494, 6650, 3740
3825, 100, 101, 487, 272, 1397, 2131, 2156, 
2894, 2893, 5624
3826, 467, 816, 117, 468, 7372, 7491, 1903, 
1906, 7918, 1904
3827, 56, 53, 54, 391, 3872, 1745, 1749, 
6298, 1742, 3761
3828, 1155, 1167, 1242, 1243, 7449, 7973, 7529, 
6819, 7448, 8012
3829, 1212, 1158, 283, 833, 6015, 5301, 8071, 
6016, 6014, 3269
3830, 919, 907, 923, 909, 5886, 6588, 3927, 
7203, 3825, 6586
3831, 687, 226, 227, 692, 2832, 1547, 2833, 
7900, 2926, 2925
3832, 1266, 228, 693, 819, 5796, 2928, 5136, 
4904, 3206, 3388
3833, 1212, 709, 833, 283, 5710, 3268, 6016, 
8071, 2972, 3269
3834, 922, 925, 891, 919, 3934, 6471, 8007, 
3932, 3930, 5888
3835, 919, 287, 901, 891, 8019, 3783, 5887, 
5888, 3753, 3797
3836, 925, 919, 909, 891, 3930, 7203, 6472, 
6471, 5888, 3816
3837, 668, 1265, 761, 1029, 6583, 6301, 6584, 
6481, 7576, 6542
3838, 771, 772, 1286, 822, 3337, 6935, 5106, 
3669, 3407, 5107
3839, 1217, 1214, 1221, 1160, 5905, 5908, 5906, 
7413, 6196, 7412
3840, 402, 383, 403, 913, 3868, 3865, 1775, 
3880, 5609, 3881
3841, 520, 519, 180, 1052, 2218, 2026, 2027, 
6886, 7811, 4506
3842, 181, 520, 180, 1052, 2028, 2027, 1490, 
4505, 6886, 4506
3843, 1267, 1265, 1266, 668, 5187, 5189, 4949, 
4953, 6583, 4954
3844, 289, 592, 481, 1276, 4934, 2338, 4932, 
7670, 8002, 6593
3845, 1215, 1216, 1160, 1217, 8126, 6143, 6191, 
6413, 6533, 7413
3846, 468, 739, 320, 493, 7916, 3035, 7917, 
2192, 7871, 7869
3847, 406, 383, 386, 888, 5608, 3743, 7129, 
5606, 3795, 3748
3848, 467, 563, 816, 468, 2265, 7373, 7372, 
1906, 2544, 7918
3849, 196, 538, 195, 1104, 2064, 2063, 1508, 
4723, 7778, 4721
3850, 859, 777, 1298, 1294, 3492, 7371, 6022, 
6671, 6673, 7800
3851, 475, 409, 300, 29, 8066, 6161, 6384, 
6385, 5367, 1629
3852, 1200, 1132, 442, 1141, 7210, 4837, 6746, 
7557, 4219, 4868
3853, 1333, 132, 932, 131, 5221, 3966, 5222, 
7268, 1431, 3967
3854, 797, 369, 1136, 798, 3150, 4846, 7690, 
3363, 3153, 7375
3855, 284, 917, 1160, 283, 6124, 7360, 6185, 
1611, 5563, 5304
3856, 222, 1167, 1, 26, 5989, 6492, 2830, 
1542, 5990, 1571
3857, 1167, 596, 69, 1, 6504, 2351, 6491, 
6492, 2453, 1364
3858, 1062, 1072, 1075, 1286, 4611, 4615, 4610, 
8034, 8115, 5079
3859, 89, 1321, 680, 681, 5101, 5104, 2816, 
2819, 7087, 2766
3860, 196, 197, 539, 1096, 1509, 2066, 2065, 
4691, 4690, 6340
3861, 410, 397, 942, 396, 6131, 4020, 6132, 
3953, 3855, 8089
3862, 992, 328, 748, 327, 4272, 3052, 7538, 
4271, 1662, 3053
3863, 918, 893, 411, 389, 5759, 6454, 3896, 
6887, 3758, 7102
3864, 866, 578, 1247, 1165, 6986, 6988, 6987, 
7004, 7701, 7070
3865, 777, 1302, 1298, 1294, 7906, 7776, 7371, 
6673, 7798, 7800
3866, 790, 1116, 1332, 1331, 6713, 7792, 5455, 
5456, 8061, 5457
3867, 1291, 696, 1288, 774, 7860, 6664, 6441, 
5971, 3473, 6665
3868, 1271, 427, 1178, 1044, 7908, 8113, 5159, 
7763, 4480, 7948
3869, 929, 963, 928, 953, 5134, 5772, 3958, 
7143, 4089, 5773
3870, 410, 390, 392, 894, 5519, 3760, 7514, 
7881, 3772, 3763
3871, 1328, 845, 1205, 863, 8101, 8109, 5504, 
7645, 3601, 8023
3872, 662, 1247, 1222, 578, 6641, 6990, 8075, 
2709, 6988, 6989
3873, 1184, 871, 822, 697, 7680, 3658, 8016, 
4964, 3657, 3387
3874, 1184, 238, 822, 676, 8015, 3216, 8016, 
6837, 2752, 7604
3875, 1011, 333, 334, 755, 4345, 1669, 4346, 
6221, 3067, 3066
3876, 1011, 1253, 334, 1012, 6222, 7588, 4346, 
4350, 7215, 4348
3877, 658, 662, 1222, 578, 2676, 8075, 7983, 
2648, 2709, 6989
3878, 1203, 637, 635, 1353, 5046, 2471, 5086, 
7161, 8095, 7160
3879, 1157, 886, 1211, 833, 7022, 7021, 6051, 
6050, 3735, 6052
3880, 685, 1202, 550, 95, 5592, 5593, 5594, 
2827, 6216, 2151
3881, 797, 684, 1202, 248, 7474, 7816, 5611, 
3226, 2776, 5610
3882, 658, 1224, 1223, 642, 5972, 5695, 5973, 
2621, 6341, 6343
3883, 1232, 418, 1163, 1229, 7196, 7201, 7989, 
7400, 7888, 7266
3884, 708, 485, 281, 282, 4981, 5604, 2969, 
2970, 5258, 1609
3885, 1362, 1153, 1152, 380, 5723, 2349, 5701, 
6898, 2348, 2350
3886, 790, 791, 363, 1331, 3356, 3139, 3136, 
5456, 7518, 7519
3887, 1184, 1287, 457, 676, 7911, 7334, 6590, 
6837, 6955, 6838
3888, 810, 379, 1151, 378, 3181, 1899, 7163, 
3180, 1725, 2552
3889, 1175, 1259, 671, 455, 6825, 5130, 6204, 
6320, 5817, 5818
3890, 964, 929, 939, 930, 5133, 3996, 6710, 
6709, 3961, 3997
3891, 637, 552, 635, 1353, 2470, 2444, 2471, 
8095, 7073, 7160
3892, 636, 1196, 553, 542, 6661, 7039, 2446, 
2447, 6708, 2252
3893, 1352, 1203, 841, 1191, 7511, 5922, 6387, 
7042, 5085, 6839
3894, 878, 471, 657, 587, 6278, 2612, 7431, 
8043, 2326, 2659
3895, 1324, 883, 1315, 700, 7587, 5707, 5431, 
6693, 3699, 6692
3896, 1363, 1362, 212, 1152, 5700, 5724, 5093, 
5094, 5701, 2711
3897, 1227, 607, 1230, 1222, 6911, 6909, 6910, 
6864, 7167, 7209
3898, 607, 1228, 1230, 1222, 7146, 7180, 6909, 
7167, 7077, 7209
3899, 804, 739, 803, 1355, 3413, 3646, 3368, 
5364, 8070, 5117
3900, 1361, 562, 555, 3, 6128, 2114, 8117, 
6126, 2287, 2161
3901, 747, 991, 748, 327, 7526, 7527, 3312, 
3050, 4270, 3053
3902, 1215, 1156, 986, 1211, 8125, 5832, 6281, 
5819, 5834, 5813
3903, 106, 313, 312, 151, 7306, 1644, 8096, 
2312, 4170, 4168
3904, 743, 324, 323, 976, 3042, 1657, 3043, 
7463, 4203, 4202
3905, 816, 468, 252, 117, 7918, 7846, 3194, 
7491, 1904, 2856
3906, 905, 925, 906, 899, 6836, 8069, 3838, 
3837, 6261, 3811
3907, 555, 3, 110, 1361, 2161, 1407, 2162, 
8117, 6126, 8118
3908, 410, 936, 942, 928, 3982, 6997, 6132, 
3954, 3995, 6951
3909, 731, 702, 732, 470, 3433, 3414, 3286, 
6054, 6056, 6026
3910, 71, 665, 1241, 664, 2785, 7119, 7862, 
2782, 2723, 6372
3911, 1156, 1210, 1211, 1157, 5833, 5828, 5834, 
6049, 7023, 6051
3912, 263, 3, 1361, 110, 2879, 6126, 7851, 
2880, 1407, 8118
3913, 410, 942, 953, 928, 6132, 4070, 5521, 
3954, 6951, 5773
3914, 1237, 990, 1003, 1001, 8063, 4308, 5166, 
6843, 4325, 4322
3915, 1237, 326, 991, 747, 6842, 4269, 5168, 
7139, 3051, 7526
3916, 478, 1333, 589, 131, 5419, 5420, 2358, 
1935, 7268, 2333
3917, 482, 922, 916, 135, 6241, 3914, 6081, 
1944, 3913, 3890
3918, 1215, 1156, 1216, 986, 8125, 5308, 8126, 
6281, 5832, 6532
3919, 810, 556, 1361, 1151, 7487, 7850, 7823, 
7163, 7879, 6927
3920, 313, 152, 151, 106, 4169, 1455, 4170, 
7306, 1894, 2312
3921, 1318, 1106, 1097, 1316, 7522, 4732, 8132, 
5933, 5552, 5551
3922, 152, 736, 601, 276, 6831, 6406, 2190, 
5500, 3425, 6879
3923, 1213, 1216, 986, 971, 5311, 6532, 8112, 
5448, 5447, 4240
3924, 1330, 1115, 1193, 789, 7934, 7936, 7784, 
7935, 7876, 7937
3925, 494, 159, 495, 1213, 1976, 1977, 2193, 
7441, 5668, 5309
3926, 324, 1219, 976, 743, 7467, 7468, 4203, 
3042, 6248, 7463
3927, 1216, 1156, 1213, 986, 5308, 5307, 5311, 
6532, 5832, 8112
3928, 1230, 1228, 1229, 1222, 7180, 7182, 7184, 
7209, 7077, 7208
3929, 584, 548, 1199, 634, 2310, 7377, 6450, 
2507, 2443, 7814
3930, 538, 537, 195, 1104, 2236, 2062, 2063, 
7778, 7779, 4721
3931, 1207, 602, 1157, 1156, 6847, 6846, 6849, 
7710, 7532, 6049
3932, 419, 500, 164, 12, 6536, 1988, 4259, 
1804, 1987, 1470
3933, 985, 981, 1228, 979, 4236, 7149, 7251, 
4235, 4227, 7181
3934, 1238, 1240, 1005, 989, 5958, 7125, 7524, 
5960, 5962, 4321
3935, 511, 14, 425, 173, 2010, 1812, 7048, 
2009, 1481, 4335
3936, 313, 832, 314, 152, 3261, 3292, 1645, 
4169, 5501, 4172
3937, 1213, 1207, 1159, 1210, 7711, 5939, 7452, 
7927, 6188, 6187
3938, 658, 603, 642, 1223, 2624, 2479, 2621, 
5973, 7859, 6343
3939, 471, 878, 864, 587, 6278, 3681, 5955, 
2326, 8043, 5929
3940, 163, 419, 1230, 979, 4192, 6538, 7972, 
4217, 4216, 7183
3941, 1279, 622, 1184, 1278, 7262, 7263, 4962, 
5200, 7770, 7771
3942, 185, 1060, 525, 184, 4544, 8029, 2038, 
1495, 4545, 2037
3943, 1284, 1061, 1069, 1283, 5747, 4581, 6574, 
5745, 5746, 5471
3944, 1317, 782, 857, 781, 6210, 3486, 7544, 
6041, 3347, 3487
3945, 1228, 163, 1230, 979, 7450, 7972, 7180, 
7181, 4217, 7183
3946, 1228, 1226, 1222, 1162, 7250, 7061, 7077, 
6775, 6778, 7078
3947, 1229, 419, 1232, 418, 7940, 7194, 7400, 
7888, 1803, 7196
3948, 1248, 421, 420, 1247, 7951, 1806, 6972, 
5923, 5583, 6973
3949, 1316, 882, 825, 857, 7543, 3656, 5714, 
5713, 3630, 3663
3950, 192, 193, 534, 1088, 1504, 2056, 2055, 
4652, 4651, 5271
3951, 1299, 1278, 1279, 867, 5197, 5200, 5198, 
5206, 8129, 7213
3952, 1248, 421, 1008, 420, 7951, 4338, 6412, 
6972, 1806, 4339
3953, 1228, 1226, 1229, 1222, 7250, 7252, 7182, 
7077, 7061, 7208
3954, 209, 1204, 445, 21, 6798, 5299, 4003, 
1524, 7165, 1840
3955, 166, 167, 503, 989, 1473, 1994, 1993, 
4263, 4262, 5963
3956, 504, 1240, 1167, 448, 6312, 7322, 6502, 
2669, 7961, 6503
3957, 1195, 1198, 1335, 631, 5423, 5110, 8041, 
5426, 5424, 5512
3958, 337, 336, 759, 1027, 1673, 3075, 3074, 
4412, 4411, 6512
3959, 716, 291, 1277, 30, 2986, 7842, 6662, 
2985, 1619, 7393
3960, 820, 1258, 1262, 758, 6862, 6807, 6458, 
3654, 6939, 6489
3961, 1362, 1153, 558, 212, 5723, 7234, 7990, 
5724, 2710, 2104
3962, 1259, 1175, 1261, 615, 6825, 6812, 7787, 
7290, 6318, 6834
3963, 28, 280, 1360, 109, 1607, 5844, 5843, 
2911, 2909, 6803
3964, 784, 824, 1319, 242, 3538, 7064, 6035, 
3223, 3220, 6036
3965, 694, 760, 759, 1263, 3649, 3325, 3648, 
5683, 6514, 6515
3966, 1164, 746, 818, 848, 7294, 3558, 7132, 
7131, 3460, 3559
3967, 450, 1165, 73, 451, 7384, 7307, 1850, 
1854, 6333, 1852
3968, 925, 890, 906, 899, 6442, 3806, 8069, 
6261, 3800, 3811
3969, 1164, 746, 1237, 818, 7294, 6844, 7295, 
7132, 3558, 4922
3970, 1281, 431, 524, 1060, 5486, 5054, 8054, 
6304, 4577, 8028
3971, 770, 429, 1280, 1072, 6931, 5882, 6932, 
6544, 4550, 8114
3972, 600, 588, 707, 587, 2574, 4984, 4986, 
2629, 2330, 5957
3973, 1072, 771, 1286, 1280, 6543, 5106, 8115, 
8114, 7775, 7677
3974, 1063, 772, 1286, 771, 6933, 6935, 6934, 
8116, 3337, 5106
3975, 1287, 1071, 1075, 1286, 7812, 4598, 5081, 
5078, 7826, 5079
3976, 1184, 1287, 1281, 457, 7911, 7825, 7773, 
6590, 7334, 8083
3977, 1234, 1164, 1231, 1237, 7257, 7171, 7954, 
7709, 7295, 7296
3978, 1176, 1261, 1258, 1257, 7786, 6809, 5390, 
5388, 7046, 5387
3979, 1258, 1259, 847, 1175, 7788, 6824, 6940, 
6808, 6825, 6826
3980, 715, 1276, 290, 30, 5515, 6596, 2983, 
2984, 6595, 1618
3981, 969, 941, 940, 939, 5488, 4011, 6283, 
6086, 4017, 4018
3982, 263, 809, 810, 1361, 3244, 3372, 3419, 
7851, 7950, 7823
3983, 1240, 1236, 1238, 1005, 7123, 6525, 5958, 
7125, 7126, 7524
3984, 1240, 1236, 664, 1238, 7123, 6527, 6040, 
5958, 6525, 6038
3985, 210, 555, 556, 1361, 2097, 2257, 2100, 
7112, 8117, 7850
3986, 702, 126, 260, 259, 5340, 2870, 2953, 
2954, 2875, 1583
3987, 664, 1240, 663, 1239, 6040, 7815, 2829, 
8011, 7124, 6417
3988, 636, 574, 635, 1191, 2513, 2493, 2510, 
7276, 5059, 5084
3989, 1240, 1167, 663, 1239, 7322, 6416, 7815, 
7124, 6419, 6417
3990, 799, 841, 858, 1352, 3438, 3537, 3491, 
5385, 6387, 7669
3991, 937, 130, 477, 131, 3983, 1933, 5764, 
3986, 1430, 1934
3992, 1359, 562, 1361, 1360, 5575, 6128, 5470, 
7791, 6129, 6130
3993, 951, 401, 404, 405, 7155, 3862, 4043, 
4044, 3867, 1778
3994, 23, 562, 555, 1361, 2111, 2114, 2098, 
6760, 6128, 8117
3995, 1191, 1351, 1196, 1325, 7040, 7038, 7275, 
7041, 5378, 6003
3996, 485, 486, 281, 138, 2178, 6120, 5604, 
1950, 1951, 5605
3997, 708, 485, 588, 281, 4981, 2365, 4982, 
2969, 5604, 6119
3998, 1257, 1258, 1256, 424, 5387, 5389, 5318, 
5196, 6813, 5320
3999, 1264, 1039, 1263, 1262, 6783, 6785, 6784, 
6894, 6308, 6477
4000, 1351, 635, 1191, 553, 7158, 5084, 7040, 
6753, 2445, 7277
4001, 285, 483, 1161, 1160, 7931, 6549, 7383, 
6505, 6547, 6548
4002, 588, 281, 707, 708, 6119, 2968, 4984, 
4982, 2969, 3264
4003, 915, 485, 282, 281, 5603, 5258, 6315, 
5027, 5604, 1609
4004, 1329, 636, 542, 1196, 6645, 2447, 6705, 
5022, 6661, 6708
4005, 865, 1346, 795, 862, 6311, 6297, 3522, 
3523, 6313, 3500
4006, 291, 1188, 292, 717, 8035, 5265, 1620, 
2987, 5263, 2988
4007, 1010, 1170, 1023, 1250, 7635, 7565, 4384, 
7016, 7550, 7644
4008, 1114, 1325, 439, 438, 7685, 5377, 4767, 
4768, 7695, 1830
4009, 619, 1182, 521, 620, 4974, 4975, 2411, 
2583, 7459, 2412
4010, 795, 1345, 862, 1346, 6330, 6329, 3500, 
6297, 6730, 6313
4011, 1011, 1010, 1170, 1023, 4347, 7635, 6219, 
4385, 4384, 7565
4012, 258, 123, 308, 146, 2868, 6712, 3198, 
7113, 1962, 4157
4013, 1316, 1317, 1097, 1107, 7337, 7339, 5551, 
6364, 6208, 4754
4014, 366, 1346, 1133, 1132, 6610, 5401, 4839, 
4864, 6326, 4865
4015, 1328, 296, 875, 1192, 6373, 3578, 7646, 
7706, 8119, 5435
4016, 865, 1346, 1348, 795, 6311, 5400, 5571, 
3522, 6297, 5573
4017, 1316, 1107, 1097, 1318, 6364, 4754, 5551, 
5933, 6365, 8132
4018, 1107, 1110, 1097, 1318, 4758, 4753, 4754, 
6365, 7222, 8132
4019, 1058, 1183, 1053, 1182, 8085, 6556, 4523, 
6625, 5062, 6072
4020, 1183, 522, 1053, 1182, 5074, 6073, 6556, 
5062, 6071, 6072
4021, 1287, 1060, 1071, 1281, 6307, 4596, 7812, 
7825, 6304, 6305
4022, 156, 157, 253, 319, 1461, 6059, 6058, 
4182, 4181, 2945
4023, 274, 728, 103, 140, 3197, 5734, 2897, 
8098, 5697, 2307
4024, 1158, 484, 283, 1160, 7697, 5561, 5301, 
5302, 7121, 5304
4025, 1199, 704, 1337, 869, 5099, 6602, 7097, 
5100, 3560, 6699
4026, 1237, 326, 1001, 991, 6842, 4300, 6843, 
5168, 4269, 4304
4027, 600, 581, 657, 846, 2672, 2649, 2687, 
6487, 6485, 6981
4028, 1232, 990, 418, 1000, 7956, 4267, 7196, 
7195, 4303, 4298
4029, 1237, 990, 1234, 1003, 8063, 7957, 7709, 
5166, 4308, 7273
4030, 922, 900, 286, 891, 7566, 3780, 7501, 
8007, 3799, 3754
4031, 1050, 1058, 1048, 1183, 4524, 4540, 4530, 
7141, 8085, 7142
4032, 441, 442, 1343, 1132, 1834, 6748, 7662, 
4838, 4837, 8064
4033, 1248, 420, 1008, 1019, 6972, 4339, 6412, 
6379, 4337, 4396
4034, 1242, 997, 1245, 996, 8090, 7439, 7530, 
7385, 4290, 7967
4035, 881, 1171, 849, 763, 4956, 5595, 3622, 
3619, 8059, 3463
4036, 838, 1350, 688, 1203, 5393, 5396, 5394, 
5921, 6724, 5044
4037, 1032, 1171, 1265, 763, 7723, 7736, 5639, 
6239, 8059, 5953
4038, 1072, 346, 770, 40, 4587, 3096, 6544, 
4549, 1684, 3097
4039, 342, 765, 1045, 341, 3086, 7893, 4483, 
1679, 3087, 4482
4040, 768, 1182, 1048, 1047, 6618, 7617, 7034, 
8065, 7616, 4492
4041, 1057, 1046, 1181, 1045, 4541, 4979, 7834, 
4536, 4486, 7867
4042, 1244, 1246, 1245, 997, 5811, 4883, 6091, 
5812, 5810, 7439
4043, 1280, 430, 1062, 429, 7855, 4551, 7857, 
5882, 1818, 4552
4044, 874, 1305, 777, 1306, 5642, 7231, 3478, 
5643, 5645, 7423
4045, 1261, 424, 425, 1036, 7986, 1811, 7047, 
6896, 4440, 4439
4046, 1321, 1105, 1322, 1111, 8040, 7495, 6690, 
5314, 4749, 6265
4047, 785, 1101, 359, 1100, 8008, 4705, 3126, 
7619, 4707, 4703
4048, 410, 390, 953, 942, 5519, 4052, 5521, 
6132, 4047, 4070
4049, 1322, 680, 679, 573, 7152, 2763, 5285, 
6223, 5103, 8009
4050, 240, 1190, 679, 678, 7407, 5286, 2759, 
2757, 7637, 2840
4051, 1200, 1345, 1199, 1343, 6949, 6729, 6398, 
6400, 7663, 6399
4052, 1179, 765, 1045, 1181, 7744, 7893, 6878, 
5718, 7106, 7867
4053, 1349, 1146, 1136, 1350, 7666, 4134, 7374, 
5557, 7795, 7692
4054, 1327, 1191, 1205, 1325, 8131, 7969, 5778, 
5777, 7041, 5779
4055, 112, 1363, 466, 557, 7539, 5333, 1900, 
2318, 8120, 2275
4056, 214, 559, 560, 1154, 2105, 2262, 2108, 
2701, 7661, 5636
4057, 1292, 1288, 1070, 1074, 5751, 7674, 6613, 
7389, 7390, 4593
4058, 1076, 1288, 1074, 1070, 7673, 7390, 4609, 
4606, 7674, 4593
4059, 562, 1360, 561, 3, 6129, 6804, 2113, 
2287, 6127, 2160
4060, 1242, 997, 1004, 1244, 8090, 4309, 7386, 
7528, 5812, 6466
4061, 1318, 1106, 1110, 1097, 7522, 4741, 7222, 
8132, 4732, 4753
4062, 1242, 997, 996, 1004, 8090, 4290, 7385, 
7386, 4309, 4312
4063, 1200, 1132, 1343, 442, 7210, 8064, 6400, 
6746, 4837, 6748
4064, 1283, 1287, 675, 526, 7341, 6957, 7099, 
5473, 7335, 7610
4065, 476, 130, 931, 129, 1932, 3964, 6571, 
1931, 1429, 3965
4066, 819, 687, 227, 692, 7899, 2833, 3207, 
3381, 7900, 2925
4067, 409, 5, 475, 129, 1787, 1929, 8066, 
3963, 1428, 1930
4068, 129, 300, 475, 409, 6162, 6384, 1930, 
3963, 6161, 8066
4069, 398, 936, 942, 396, 6996, 6997, 4021, 
3852, 3951, 8089
4070, 384, 383, 913, 887, 1732, 5609, 6985, 
3745, 3744, 5830
4071, 951, 959, 935, 938, 4080, 7156, 7082, 
7081, 6509, 4015
4072, 397, 398, 942, 396, 1768, 4021, 4020, 
3855, 3852, 8089
4073, 537, 1095, 1104, 1318, 6721, 4722, 7779, 
6720, 6722, 7780
4074, 434, 1295, 541, 1103, 7746, 5321, 7505, 
4716, 5324, 5322
4075, 1168, 1223, 1248, 1249, 7232, 7005, 7982, 
5926, 7193, 6381
4076, 39, 764, 1055, 1271, 3085, 7533, 4478, 
4894, 4893, 7765
4077, 1329, 636, 624, 542, 6645, 2570, 6646, 
6705, 2447, 2420
4078, 793, 794, 1345, 861, 3359, 6327, 4995, 
3499, 3498, 6328
4079, 765, 1274, 854, 715, 7365, 5568, 3476, 
3624, 6792, 3682
4080, 1046, 343, 767, 766, 4485, 3091, 7974, 
7175, 3088, 3332
4081, 1179, 1044, 1054, 1057, 7947, 4516, 6082, 
6876, 4521, 4520
4082, 1047, 1180, 1059, 1046, 7896, 4977, 4527, 
4489, 4976, 4526
4083, 656, 1328, 1205, 624, 5505, 5504, 5508, 
2674, 7362, 6649
4084, 1260, 644, 1269, 585, 5846, 5849, 5847, 
7579, 2708, 7297
4085, 1113, 545, 1335, 1340, 5835, 6270, 7767, 
5837, 5836, 5109
4086, 1255, 1017, 1015, 1022, 5900, 4367, 7138, 
7592, 4381, 4380
4087, 1021, 1010, 1023, 1250, 4399, 4384, 4400, 
5660, 7016, 7644
4088, 111, 1363, 839, 112, 8106, 7486, 8105, 
1409, 7539, 8104
4089, 1022, 1254, 1017, 1020, 7591, 5901, 4381, 
4390, 7031, 4376
4090, 441, 1132, 1343, 1345, 4838, 8064, 7662, 
4997, 7211, 7663
4091, 676, 457, 84, 1287, 6838, 1868, 2809, 
6955, 7334, 6956
4092, 1333, 296, 297, 932, 6374, 1625, 6099, 
5222, 6573, 7466
4093, 1083, 1312, 1091, 1082, 7618, 7626, 4674, 
4636, 7223, 4673
4094, 1316, 537, 536, 640, 6719, 2235, 5797, 
5252, 2467, 2469
4095, 1099, 1110, 1318, 1108, 4756, 7222, 6952, 
4743, 4755, 7843
4096, 1100, 784, 785, 1319, 7053, 3350, 7619, 
7055, 6035, 7508
4097, 1312, 1083, 354, 1082, 7618, 4634, 7545, 
7223, 4636, 4632
4098, 1095, 1110, 1104, 1318, 4740, 4742, 4722, 
6722, 7222, 7780
4099, 1318, 1106, 1095, 1110, 7522, 4739, 6722, 
7222, 4741, 4740
4100, 1295, 1109, 1322, 1103, 5038, 6264, 5325, 
5324, 4735, 5326
4101, 1104, 1321, 538, 681, 7415, 7831, 7778, 
7414, 7087, 7305
4102, 781, 1310, 1084, 780, 5720, 5599, 5721, 
3346, 6579, 7428
4103, 465, 728, 139, 140, 5598, 5696, 2181, 
2182, 5697, 1441
4104, 1087, 190, 532, 191, 4650, 2051, 7807, 
4649, 1502, 2052
4105, 4, 554, 1204, 576, 2278, 7166, 5667, 
2322, 2274, 8123
4106, 28, 809, 263, 1361, 3245, 3244, 1587, 
6926, 7950, 7851
4107, 1359, 562, 561, 215, 5575, 2113, 6756, 
5576, 2112, 2109
4108, 189, 434, 1077, 530, 4616, 4648, 4618, 
2048, 8004, 6356
4109, 1047, 1180, 1182, 1059, 7896, 4973, 7616, 
4527, 4977, 7822
4110, 1335, 632, 1340, 545, 5108, 5111, 5109, 
6270, 2438, 5836
4111, 216, 1354, 444, 22, 6346, 5461, 3724, 
1534, 5460, 1838
4112, 1322, 680, 1319, 679, 7152, 7153, 6689, 
5285, 2763, 7065
4113, 765, 1179, 854, 1274, 7744, 6272, 3476, 
7365, 5717, 5568
4114, 431, 1051, 1278, 523, 4501, 5741, 5483, 
5053, 5073, 5485
4115, 966, 933, 950, 957, 7095, 6030, 4118, 
4095, 6968, 4107
4116, 1276, 520, 618, 619, 7578, 2409, 6636, 
6635, 2410, 2582
4117, 1184, 1280, 1278, 1281, 7676, 5880, 7771, 
7773, 8013, 5484
4118, 1210, 1156, 1207, 1157, 5833, 7710, 6188, 
7023, 6049, 6849
4119, 253, 157, 118, 319, 6059, 1907, 2858, 
2945, 4181, 7848
4120, 1221, 1161, 1219, 1225, 7417, 7938, 7534, 
7535, 5675, 7352
4121, 1210, 1207, 1156, 1213, 6188, 7710, 5833, 
7927, 7711, 5307
4122, 681, 538, 1104, 1318, 7305, 7778, 7414, 
7144, 6338, 7780
4123, 785, 1101, 786, 359, 8008, 6800, 3351, 
3126, 4705, 3129
4124, 706, 727, 737, 491, 3442, 3441, 3423, 
6393, 6998, 5854
4125, 295, 1308, 294, 932, 6682, 5144, 1623, 
6572, 5225, 7840
4126, 820, 1258, 847, 1175, 6862, 6940, 3459, 
5987, 6808, 6826
4127, 566, 567, 1358, 840, 2268, 6122, 4911, 
6057, 6759, 6758
4128, 933, 385, 407, 950, 6029, 5565, 3971, 
6030, 4041, 7246
4129, 1188, 291, 292, 133, 8035, 1620, 5265, 
7844, 8086, 5247
4130, 643, 1296, 1279, 1300, 5095, 8060, 8005, 
6392, 5347, 8055
4131, 804, 805, 868, 1357, 3369, 3640, 3540, 
5363, 5065, 5068
4132, 816, 468, 319, 252, 7918, 7847, 3193, 
3194, 7846, 2946
4133, 1213, 494, 1207, 602, 7441, 5937, 7711, 
7442, 2375, 6847
4134, 826, 148, 469, 492, 6453, 2186, 6463, 
6462, 1963, 2187
4135, 1260, 661, 614, 1174, 6611, 2647, 8077, 
5356, 6423, 6631
4136, 630, 1335, 1334, 544, 5529, 5532, 5530, 
2435, 6269, 6107
4137, 494, 1213, 1207, 1159, 7441, 7711, 5937, 
5940, 7452, 5939
4138, 589, 1195, 647, 1338, 7204, 5425, 2525, 
7886, 6096, 5290
4139, 1161, 606, 1225, 1218, 5673, 5674, 5675, 
8091, 7454, 7117
4140, 1101, 1100, 1319, 1111, 4707, 7055, 5417, 
4745, 4746, 5418
4141, 1198, 647, 1195, 1338, 5422, 5425, 5423, 
5946, 5290, 6096
4142, 1198, 660, 1336, 632, 5944, 5947, 5945, 
5112, 2705, 8047
4143, 156, 317, 254, 155, 4179, 2950, 7079, 
1460, 4180, 6970
4144, 1234, 1003, 990, 1000, 7273, 4308, 7957, 
7962, 4307, 4303
4145, 1169, 1006, 507, 1168, 7395, 7398, 7396, 
7639, 5737, 7279
4146, 1338, 654, 1336, 660, 6174, 6175, 5948, 
5292, 2683, 5947
4147, 79, 1175, 454, 670, 6203, 6319, 1861, 
2796, 6205, 7700
4148, 566, 805, 840, 1358, 4914, 3641, 6057, 
4911, 4910, 6758
4149, 112, 265, 1363, 839, 2883, 5331, 7539, 
8104, 3417, 7486
4150, 475, 486, 29, 600, 2179, 6090, 6385, 
2368, 2367, 6089
4151, 559, 813, 814, 1154, 6390, 3377, 5317, 
7661, 7509, 5637
4152, 513, 1034, 1024, 175, 6321, 4441, 6322, 
2014, 4435, 4402
4153, 871, 1184, 822, 1286, 7680, 8016, 3658, 
5105, 7679, 5107
4154, 1352, 1203, 1349, 841, 7511, 6755, 6258, 
6387, 5922, 5452
4155, 757, 1013, 1173, 1256, 6977, 6976, 6817, 
6816, 7984, 5358
4156, 1062, 1286, 1075, 1071, 8034, 5079, 4610, 
4589, 7826, 4598
4157, 1296, 867, 1279, 1300, 5205, 7213, 8060, 
5347, 7558, 8055
4158, 1255, 1017, 173, 1015, 5900, 4365, 7738, 
7138, 4367, 4360
4159, 519, 179, 1042, 1272, 2025, 4474, 7805, 
7728, 7594, 6085
4160, 806, 280, 840, 1358, 3449, 3426, 3556, 
7585, 6178, 6758
4161, 18, 193, 437, 535, 1505, 4621, 1828, 
2058, 2057, 5274
4162, 1314, 582, 627, 656, 5427, 2591, 5754, 
5507, 2594, 2597
4163, 841, 1191, 246, 700, 6839, 7580, 3690, 
3684, 5056, 2941
4164, 18, 535, 437, 536, 2058, 5274, 1828, 
2059, 2234, 6002
4165, 1197, 1126, 1198, 1340, 7872, 5480, 7640, 
7642, 5482, 5113
4166, 1261, 424, 1257, 425, 7986, 5196, 7046, 
7047, 1811, 7049
4167, 806, 280, 1358, 807, 3449, 6178, 7585, 
3371, 3266, 6180
4168, 1118, 1197, 1339, 792, 6367, 7653, 5246, 
6369, 6371, 4959
4169, 108, 566, 568, 840, 2610, 2542, 2129, 
4939, 6057, 6254
4170, 1329, 1328, 1334, 624, 5725, 5728, 5726, 
6646, 7362, 8130
4171, 1014, 1013, 1256, 1173, 4357, 7984, 5319, 
5219, 6976, 5358
4172, 1335, 1334, 1122, 1129, 5532, 5413, 7769, 
7703, 5412, 4826
4173, 1190, 240, 823, 678, 7407, 3218, 7406, 
7637, 2757, 4993
4174, 247, 684, 688, 1350, 2775, 2849, 2844, 
5395, 7475, 5396
4175, 1363, 212, 466, 557, 5093, 2260, 5333, 
8120, 2101, 2275
4176, 1363, 211, 212, 557, 5092, 1528, 5093, 
8120, 2102, 2101
4177, 460, 683, 682, 91, 6001, 2772, 5934, 
1876, 2823, 2820
4178, 614, 661, 638, 1174, 2647, 2646, 2626, 
6631, 6423, 5344
4179, 1178, 1273, 1269, 1271, 8080, 5017, 5158, 
5159, 5018, 5016
4180, 265, 466, 829, 113, 5330, 5332, 3247, 
2884, 1901, 5173
4181, 447, 48, 1361, 378, 1843, 7664, 5469, 
2553, 1724, 6928
4182, 1334, 1332, 1193, 1127, 6734, 5434, 5730, 
5411, 7708, 8026
4183, 1260, 1176, 1174, 1257, 5357, 5355, 5356, 
7997, 5388, 6905
4184, 840, 109, 280, 108, 6757, 2909, 3426, 
4939, 1405, 2910
4185, 225, 226, 666, 818, 1546, 2725, 2724, 
3205, 3204, 7891
4186, 876, 1220, 1222, 885, 6768, 7076, 6866, 
3728, 7946, 7443
4187, 1051, 1183, 1058, 1050, 5076, 8085, 4522, 
4503, 7141, 4524
4188, 537, 1095, 195, 1104, 6721, 4688, 2062, 
7779, 4722, 4721
4189, 788, 1326, 1205, 1330, 6696, 5776, 6703, 
7036, 6558, 7783
4190, 1171, 577, 451, 641, 5658, 2280, 6335, 
5676, 2474, 2473
4191, 853, 1297, 787, 1295, 7630, 6918, 3475, 
8121, 6919, 6921
4192, 482, 134, 135, 916, 1943, 1435, 1944, 
6081, 3891, 3890
4193, 200, 544, 543, 1334, 2075, 2242, 2074, 
7366, 6107, 6108
4194, 1334, 1332, 1192, 1193, 6734, 5437, 5534, 
5730, 5434, 5433
4195, 478, 639, 649, 1333, 2463, 2546, 2533, 
5419, 7933, 5421
4196, 1196, 1124, 439, 440, 5019, 4798, 7515, 
6707, 4797, 1831
4197, 137, 915, 282, 917, 3929, 6315, 6490, 
3892, 3936, 5562
4198, 1131, 551, 1350, 1140, 5790, 7821, 8128, 
4853, 8093, 7796
4199, 1129, 1332, 1127, 1116, 6735, 7708, 4829, 
4814, 7792, 4828
4200, 1205, 788, 1330, 863, 6703, 7036, 7783, 
8023, 3503, 8046
4201, 1327, 438, 1137, 1325, 7694, 4851, 5382, 
5777, 7695, 5380
4202, 1326, 1114, 1323, 1330, 5841, 7686, 6925, 
6558, 6557, 7781
4203, 614, 1257, 511, 615, 6904, 6967, 2400, 
2488, 7998, 2401
4204, 1257, 614, 1174, 1260, 6904, 6631, 6905, 
7997, 8077, 5356
4205, 1160, 1161, 285, 710, 6548, 7383, 6505, 
6255, 7311, 2974
4206, 1262, 1039, 1263, 1027, 6308, 6785, 6477, 
7593, 4465, 6513
4207, 1043, 181, 521, 182, 4476, 2029, 4988, 
4475, 1491, 2030
4208, 556, 263, 1361, 110, 7849, 7851, 7850, 
2315, 2880, 8118
4209, 85, 1184, 676, 677, 6589, 6837, 2808, 
2811, 5011, 2755
4210, 589, 1195, 649, 647, 7204, 7205, 2532, 
2525, 5425, 2653
4211, 1327, 1191, 858, 1205, 8131, 6840, 7668, 
5778, 7969, 7976
4212, 1330, 1127, 1193, 1115, 8027, 8026, 7784, 
7934, 4823, 7936
4213, 542, 440, 1196, 553, 6706, 6707, 6708, 
2252, 7085, 7039
4214, 621, 1299, 1183, 579, 7611, 5008, 7612, 
2585, 5199, 7104
4215, 824, 679, 1319, 680, 7063, 7065, 7064, 
8049, 2763, 7153
4216, 453, 1264, 454, 513, 7742, 8022, 1862, 
2645, 6323, 2644
4217, 199, 542, 19, 440, 2072, 2071, 1512, 
4759, 6706, 1832
4218, 548, 20, 1342, 547, 2083, 7901, 5509, 
2246, 2082, 5510
4219, 1271, 427, 1270, 1178, 7908, 7909, 4903, 
5159, 8113, 5157
4220, 1293, 1177, 623, 1292, 7945, 7966, 7922, 
7243, 6427, 7992
4221, 553, 440, 19, 542, 7085, 1832, 2094, 
2252, 6706, 2071
4222, 1290, 1076, 1061, 1070, 7567, 4607, 5744, 
6612, 4606, 4588
4223, 1267, 667, 452, 76, 4947, 4950, 4948, 
6727, 2790, 1857
4224, 863, 788, 870, 1205, 3503, 3547, 3549, 
8023, 6703, 8108
4225, 1313, 1189, 534, 1311, 5614, 5282, 5782, 
5613, 5281, 5267
4226, 1335, 1113, 1126, 1129, 7767, 4806, 5481, 
7703, 4821, 4820
4227, 507, 170, 508, 1016, 2002, 2003, 2206, 
7281, 4364, 7280
4228, 664, 691, 665, 1235, 8127, 8050, 2723, 
6501, 6493, 7120
