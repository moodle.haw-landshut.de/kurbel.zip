5836, 14.085225, 7.5203935, 188.79773
5837, 12.094477, 15.198586, 194.50246
5838, 16.445318, 7.5203935, 196.18271
5839, -124.322, 10.514197, 168.04368
5840, -34.553722, 44.956008, 223.50901
5841, -33.644734, 40.57823, 218.3667
5842, -33.149758, 46.31366, 217.17278
5843, 1186.4066, 45.021955, 134.08079
5844, 1151.7035, 45.021955, 134.34404
5845, 1163.7791, 45.021955, 109.47757
5846, -207.51991, 10.418945, -77.676374
5847, -213.35487, 24.346577, -78.983191
5848, -199.59816, 25.828981, -77.084301
5849, -218.85669, 13.927631, -65.986008
5850, -205.09998, 15.410036, -64.087119
5851, -210.93495, 29.337667, -65.393936
5852, 1296.0625, 30, -71.022276
5853, 1314.8822, 30, -64.556817
5854, 763.82879, 30, 34.256245
5855, 792.588, 30, 17.369562
5856, 766.33089, 30, 3.1945792
5857, 795.0901, 30, -13.692104
5858, -123.97479, 44.708628, -201.25638
5859, -116.66561, 44.708628, -191.37657
5860, -125.54654, 44.708628, -190.66141
5861, -8.1143767, 45.021506, -291.4344
5862, -138.20461, 14.433758, 223.45172
5863, -103.094, 79.165172, -65.403707
5864, 29.812889, 15.554016, -251.057
5865, 120.19339, 30, 194.52175
5866, 92.320657, 30, 188.42846
5867, 118.88809, 30, 226.38472
5868, 91.015361, 30, 220.29143
5869, -23.389153, 24.856675, -259.34519
5870, -24.878448, 15.325372, -257.84982
5871, -18.18701, 15.948422, -262.29814
5872, 106.19806, 171.01859, -36.478502
5873, 93.398993, 207.5462, -78.383678
5874, 6.0702564, 109.0772, 122.02078
5875, 146.66478, 30, -206.06879
5876, 1287.7696, 30, -50.753928
5877, 1306.5894, 30, -44.288469
5878, -225.59762, 37.127382, 40.540781
5879, -218.80609, 44.657382, 48.815583
5880, -231.65289, 34.817264, 46.997252
5881, -221.20846, 52.47, 38.274802
5882, -234.05526, 42.629882, 36.456471
5883, -227.26372, 50.159882, 44.731273
5884, -144.05024, 10.668451, -194.43214
5885, -139.11206, 7.5, -191.15102
5886, -82.687454, 124.17236, -90.389434
5887, -87.051364, 97.349548, -86.657713
5888, -71.526992, 98.177998, -97.703078
5889, -62.669635, 45.92583, -227.76944
5890, -53.045994, 51.052475, -224.87416
5891, -51.719053, 52.116005, -232.08024
5892, -54.309628, 36.978305, -223.77118
5893, -52.982687, 38.041835, -230.97727
5894, -43.359046, 43.16848, -228.08199
5895, -15.755653, 29.764156, -270.31297
5896, -13.137254, 25.578533, -261.20236
5897, -16.812016, 17.345243, -269.93466
5898, -26.007552, 29.042298, -268.45579
5899, -160.40615, 7.894153, -123.91177
5900, -163.78802, 16.80339, -123.47718
5901, -154.2248, 17.372403, -124.26541
5902, -165.38102, 8.9092367, -116.07186
5903, -155.81781, 9.4782499, -116.8601
5904, -159.19967, 18.387487, -116.42551
5905, 5.08572, 35.897719, -184.62006
5906, 0.76983483, 28.540523, -186.07326
5907, 5.3683476, 28.807156, -192.42914
5908, -2.8774357, 37.785292, -183.90203
5909, 1.7210771, 38.051925, -190.25791
5910, -2.5948081, 30.694729, -191.71111
5911, -159.34049, 18.536598, -198.59396
5912, -169.24191, 16.271924, -200.29247
5913, -163.27037, 25.726312, -197.69393
5914, -193.2955, 53.066307, -179.84492
5915, -188.07438, 52.66899, -185.33969
5916, -268.25694, 7.5600431, -15.821359
5917, -272.12738, 6.7900757, -5.4226963
5918, -263.84883, 7.766084, -9.3922432
5919, 711.23309, 30, -15.12483
5920, -61.773217, 45.437717, 279.47755
5921, -45.007061, 45.437717, 272.20079
5922, -54.120763, 45.437717, 262.57263
5923, -123.10626, 33.034279, -187.86733
5924, -115.44517, 48.32565, -181.66395
5925, -124.3261, 48.32565, -180.94879
5926, -111.35885, 32.194091, -161.7589
5927, -114.50735, 28.329143, -150.55844
5928, 205.61461, 30, -108.76059
5929, 243.16141, 30, -99.206444
5930, 234.87083, 30, -139.55517
5931, -161.57572, 29.422826, 224.31601
5932, -153.07336, 14.433758, 216.52429
5933, -154.31936, 31.155814, 207.63227
5934, -172.10819, 14.989068, 231.74915
5935, -173.35419, 31.711124, 222.85712
5936, -164.85183, 16.722056, 215.0654
5937, 49.139357, 14.32846, -220.90526
5938, 49.14975, 20.785207, -228.87241
5939, 47.486252, 26.010268, -223.50593
5940, 41.227774, 11.681809, -220.62648
5941, -212.669, 45.410036, -63.024172
5942, -199.93518, 45.410036, -74.589307
5943, -213.69189, 43.927631, -76.488197
5944, 30.152569, 16.001912, 163.44816
5945, 36.864121, 30.283599, 170.8112
5946, 23.034575, 30.532338, 152.76266
5947, 47.878749, 14.281687, 164.99708
5948, 40.760754, 28.812113, 154.31157
5949, 63.896093, 46.460944, 253.08329
5950, 76.373182, 46.460944, 254.43138
5951, 1298.9119, 15.821482, -8.9926977
5952, -152.98813, 52.001941, -209.59371
5953, -151.24146, 52.001941, -200.67908
5954, -161.08949, 52.001941, -204.15774
5955, 288.14272, 30, -118.40237
5956, -158.97718, 13.83421, 25.61067
5957, 218.07507, 30, -71.140223
5958, 3.4373765, 18.708709, -272.03593
5959, 0.11962773, 9.0335504, -271.92067
5960, -0.079045591, 16.670754, -264.55038
5961, 10.117122, 9.6751585, -272.16477
5962, 9.9184487, 17.312362, -264.79449
5963, 6.6007, 7.6372034, -264.67923
5964, -55.687369, 13.358952, -192.71815
5965, -42.702627, 13.358952, -187.25101
5966, -36.016053, 52.116005, -231.64404
5967, -34.619896, 45.951454, -237.96349
5968, -41.929673, 52.116005, -237.80505
5969, -34.517464, 53.835449, -240.48046
5970, -247.40082, 52.503684, -29.281303
5971, -253.31191, 50.718283, -35.935472
5972, -69.405597, 12.719601, -172.35369
5973, -85.936278, 14.836138, -183.75399
5974, -65.671246, 13.358952, -184.55587
5975, -254.66313, 8.5214843, -41.775878
5976, -246.00963, 8.5214843, -39.057529
5977, -254.40113, 8.5214843, -33.222506
5978, -22.741935, 57.359323, -120.0904
5979, -15.365141, 71.012156, -120.44574
5980, 3.205546, 54.601548, -121.48249
5981, 10.58234, 68.254381, -121.83784
5982, -131.27184, 14.708628, -198.72421
5983, -121.9247, 14.708628, -207.95624
5984, -129.61682, 31.533677, -208.62105
5985, -244.61378, 44.814472, -147.08941
5986, -234.32827, 44.814472, -129.14563
5987, -228.34136, 44.814472, -144.73083
5988, 40.786835, 53.235757, -243.04063
5989, 36.293558, 45.468133, -283.19898
5990, 54.517872, 45.468133, -279.75364
5991, 43.864313, 45.468133, -267.51679
5992, -195.81462, 52.502135, 144.38693
5993, -121.19897, 14.708628, -197.24068
5994, -228.66484, 20.572452, -56.099314
5995, 1149.9461, 44.991433, 73.32367
5996, 1173.3368, 45.007877, 72.651246
5997, 1150.6361, 14.991433, 73.32367
5998, 1151.3029, 29.999309, 85.974916
5999, -236.25215, 16.028789, -36.229613
6000, -238.46026, 23.519688, -34.065791
6001, -157.62023, 14.907353, 241.40721
6002, -140.0033, 7.5, 189.54287
6003, -43.189849, 28.066641, 227.26918
6004, -50.760546, 28.329145, 217.81281
6005, -39.99627, 33.580918, 220.86064
6006, -47.566967, 33.843422, 211.40428
6007, -150.82312, 21.44686, 200.11843
6008, -221.5655, 13.732322, -44.101393
6009, -219.24649, 14.587502, -36.648491
6010, -217.59232, 21.015133, -55.294904
6011, 43.316879, 30.827737, -181.89576
6012, 53.357367, 41.970914, -188.67447
6013, 59.521919, 26.846318, -177.69074
6014, 49.991703, 48.856823, -178.86185
6015, 56.156255, 33.732228, -167.87812
6016, 66.196742, 44.875405, -174.65683
6017, 34.545702, 22.095261, 233.21656
6018, 40.352917, 23.057287, 243.79169
6019, 41.99352, 24.695632, 232.48091
6020, 37.447819, 17.600371, 227.26434
6021, 43.255034, 18.562397, 237.83948
6022, -179.01726, 52.128699, 102.35996
6023, -181.04158, 52.128699, 115.55638
6024, -190.91798, 52.128699, 110.57173
6025, 450.35485, 30, -92.938608
6026, 437.05833, 30, -128.45171
6027, 474.8823, 30, -117.59174
6028, 105.33663, 154.19, 58.689233
6029, 109.88383, 178.51748, 32.971475
6030, 97.255927, 197.06385, 74.621468
6031, 698.21871, 30, 54.735402
6032, -129.77224, 38.304565, 183.88079
6033, -197.0719, 44.958748, 209.40917
6034, -205.81141, 35.375967, 199.27265
6035, -195.87796, 50.417219, 191.54411
6036, -210.59992, 50.417219, 194.49695
6037, -0.90818068, 9.0335504, -285.87716
6038, -8.9197885, 24.055057, -285.78985
6039, 9.0893137, 9.6751585, -286.12126
6040, 1.0777058, 24.696665, -286.03396
6041, -129.50322, 52.708256, 189.71092
6042, -138.08257, 45.178256, 188.65696
6043, -127.84766, 38.542821, 190.1042
6044, -131.42779, 52.47, 183.48751
6045, 15.125634, 46.001912, 177.77016
6046, 24.891854, 46.001912, 170.25544
6047, 19.40304, 38.510901, 180.00084
6048, 25.156953, 52.508989, 180.99399
6049, 58.726094, 29.377055, -196.37295
6050, 65.400917, 47.406141, -193.33904
6051, 56.164767, 39.84428, -200.76523
6052, 50.79604, 52.438139, -193.06676
6053, 365.33849, 30, -100.44726
6054, 418.33184, 30, -95.938027
6055, 329.38451, 30, -141.5608
6056, 382.37787, 30, -137.05157
6057, 1069.1351, 30, 83.54956
6058, 913.68309, 30, -124.03804
6059, 937.01406, 30, -117.77343
6060, 468.43667, 30, -167.7094
6061, 421.29418, 30, -175.54213
6062, 71.56547, 32.281546, -182.35531
6063, 14.231035, 9.6751585, -263.12254
6064, 16.504996, 17.558789, -261.50679
6065, 773.00532, 30, -69.821786
6066, 772.38746, 30, -39.093663
6067, 748.53045, 30, -40.52639
6068, -224.68497, 6.6448204, -44.136185
6069, -213.61246, 7.0875016, -43.331774
6070, -222.36597, 7.5, -36.683284
6071, -191.00926, 15.259182, 24.833932
6072, -195.27625, 23.154649, 19.482741
6073, -200.9213, 7.8954668, 24.835191
6074, -195.01439, 7.8954668, 15.163298
6075, -10.710376, 52.663947, 265.61978
6076, -2.8848541, 37.656287, 266.34514
6077, 3.3851648, 52.663947, 265.97784
6078, -222.82987, 6.6448204, -54.792497
6079, -211.75735, 7.0875016, -53.988086
6080, -122.57762, 16.211283, -118.40628
6081, -80.271503, 22.583402, -75.179932
6082, -206.5392, 27.351436, -32.680713
6083, -213.34023, 19.435402, -35.43675
6084, -202.63301, 22.026577, -30.237756
6085, -209.43405, 14.110543, -32.993792
6086, -31.584475, 144.45651, 118.17196
6087, -50.002842, 136.3677, 112.34849
6088, -61.608782, 164.41125, 105.62764
6089, 175.77576, 30, -4.0017029
6090, 142.92425, 30, -19.763184
6091, 40.238857, 21.316395, -243.94396
6092, 51.23428, 22.410467, -251.49416
6093, 52.659784, 21.196829, -242.78399
6094, 51.422481, 28.386092, -244.05767
6095, 17.233928, 44.530426, 143.03678
6096, 12.467423, 28.69387, 146.02903
6097, 1.2696547, 29.485725, 132.45707
6098, 2.7701424, 44.163444, 152.80279
6099, -8.4276256, 44.955299, 139.23083
6100, -13.194131, 29.118743, 142.22307
6101, -94.812848, 44.17346, 169.43836
6102, -95.682249, 45.921808, 184.43294
6103, -83.058686, 44.17346, 174.32466
6104, -83.928087, 45.921808, 189.31924
6105, -123.84574, 52.67289, 136.68751
6106, -139.07887, 43.586321, 133.24646
6107, -16.357468, 9.2212673, 189.15305
6108, -25.701939, 9.2212673, 193.45115
6109, -120.47418, 46.211283, -124.57378
6110, -108.9556, 41.872371, -122.29836
6111, -121.30611, 46.211283, -112.38089
6112, -118.88916, 28.083654, -122.93658
6113, -109.78753, 41.872371, -110.10547
6114, -147.93642, 14.908047, 78.64514
6115, -149.70066, 14.908047, 62.960903
6116, -165.03014, 28.093034, 73.258412
6117, -173.00357, 13.184987, 79.70381
6118, -174.76781, 13.184987, 64.019573
6119, 148.15581, 30, -92.637995
6120, 134.3166, 30, -54.649515
6121, 1133.9561, 14.991433, 73.32367
6122, 1119.9276, 14.991433, 90.001118
6123, 1141.4113, 14.991433, 94.065857
6124, 18.259729, 54.601548, -121.4352
6125, 26.815158, 75.114552, -120.04142
6126, 1211.2424, 14.951341, 119.9808
6127, 1186.4066, 15.021955, 134.08079
6128, 1206.2435, 14.951341, 90.624977
6129, 1181.4077, 15.021955, 104.72497
6130, 1197.649, 29.973295, 104.06159
6131, -118.17366, 331.92, 26.469924
6132, -114.17432, 307.47733, 35.298159
6133, 1181.4228, 45.021955, 104.44896
6134, 1130.9597, 14.991433, 118.56166
6135, 56.204605, 44.530426, 129.76249
6136, 56.910669, 57.571708, 107.49124
6137, 61.9654, 30, 123.70498
6138, -165.39636, 52.001941, -197.39685
6139, -157.61663, 52.001941, -197.38463
6140, -162.089, 44.314397, -197.89346
6141, -10.796777, 9.0335504, -276.54417
6142, -13.156448, 15.021506, -290.5422
6143, 17.027705, 23.420382, -173.12919
6144, 8.6117596, 14.951027, -160.72714
6145, 23.829757, 14.951027, -166.99621
6146, 14.945522, 8.4693554, -174.53896
6147, 67.549925, 43.235288, -231.24452
6148, 65.811105, 27.563748, -224.84938
6149, 69.321139, 27.97537, -238.76095
6150, 57.136655, 44.32846, -230.17985
6151, 60.64669, 44.740082, -244.09143
6152, 58.90787, 29.068542, -237.69629
6153, -7.060524, 37.966053, -192.08304
6154, -10.238397, 30.599432, -193.22818
6155, -212.5977, 52.698162, -41.047723
6156, 33.925231, 32.375308, 215.67167
6157, 34.712775, 35.604734, 221.94355
6158, 40.746373, 31.507864, 220.66315
6159, 42.57789, 36.504021, 213.86145
6160, 43.365433, 39.733447, 220.13333
6161, 113.0303, 56.82, 37.363883
6162, 106.57437, 30, 61.407401
6163, 101.00486, 50.579012, 69.141723
6164, -113.42549, 48.053732, -144.21341
6165, -119.97092, 54.584174, -152.52933
6166, -110.27699, 51.91868, -155.41387
6167, -241.52347, 45.16888, -95.532847
6168, -95.607883, 13.381781, 74.68693
6169, -78.032008, 13.381781, 92.318109
6170, -71.478122, 43.817103, 95.4743
6171, 23.897105, 30.632776, -261.98081
6172, 27.969401, 37.859504, -259.20265
6173, 28.832226, 30.310284, -258.30482
6174, 51.321834, 14.530426, 144.96726
6175, 65.15138, 14.281687, 163.01581
6176, 80.595231, 30, 138.46673
6177, 70.034152, 44.281687, 147.81104
6178, 1129.2531, 44.991433, 118.58692
6179, 1150.3627, 30.013387, 102.40446
6180, 1141.3287, 44.991433, 93.720453
6181, -41.320383, 12.719601, -144.19505
6182, -66.176618, 12.719601, -140.83912
6183, -176.90334, 8.9092367, -119.31066
6184, -175.38409, 8.9092367, -107.5172
6185, 13.108493, 44.951027, -154.256
6186, 83.516081, 43.235288, -228.69928
6187, 39.74777, 29.881247, -218.44596
6188, 47.659353, 32.527898, -218.72474
6189, 39.652073, 30.356579, -225.89351
6190, 47.563656, 33.00323, -226.17229
6191, 15.602007, 36.255305, -173.8663
6192, 24.135412, 51.304277, -179.52155
6193, -33.441881, 274.48575, -118.18917
6194, -51.653081, 293.44051, -109.31681
6195, 14.599601, 52.571244, -176.53835
6196, 6.0661964, 37.522271, -170.8831
6197, 10.97426, 43.875522, -185.43202
6198, 31.659242, 54.574185, -205.56255
6199, 35.250536, 53.816415, -210.40977
6200, 42.428581, 52.438139, -202.97988
6201, 86.130328, 47.406141, -186.49017
6202, 80.788716, 47.406141, -216.26102
6203, -244.33125, 14.814472, -147.55646
6204, -249.99177, 29.816671, -137.36472
6205, -239.7369, 29.872449, -154.66068
6206, -147.53893, 53.822068, 202.07491
6207, -140.13953, 52.708256, 204.81007
6208, -143.55738, 46.530323, 192.14521
6209, -145.87949, 53.822068, 193.2474
6210, -138.4801, 52.708256, 195.98257
6211, -155.11957, 46.693797, -196.46547
6212, 1120.3009, 45.020902, -68.337235
6213, 136.85681, 30, 242.51389
6214, 109.67799, 30, 261.23728
6215, 91.709276, 30, 245.10811
6216, 0.656389, 14.99234, 287.72451
6217, -137.1629, 46.211283, -123.66354
6218, -141.2907, 36.681044, -120.59235
6219, -137.95193, 38.88394, -130.4417
6220, -148.04586, 50.469762, -119.04388
6221, -144.70709, 52.672657, -128.89323
6222, -148.83489, 43.142419, -125.82205
6223, -213.03226, 9.7618092, 169.11477
6224, 68.94034, 30.680944, 276.85728
6225, 56.297044, 44.22, 284.41404
6226, 62.603432, 14.740082, -241.31612
6227, 69.506667, 13.235288, -228.46921
6228, 59.093398, 14.32846, -227.40454
6229, 12.94173, 226.24286, 118.85491
6230, 43.969878, 242.46679, 114.80389
6231, 18.181759, 252.76152, 119.09271
6232, -108.2801, 174.19407, 56.281916
6233, -153.70979, 44.433758, 216.72731
6234, -172.74462, 44.989068, 231.95217
6235, -115.357, 151.27386, -32.985359
6236, -123, 134.82, -9.184851e-15
6237, 61.83874, 31.456393, 250.20671
6238, 77.174834, 14.995449, 240.88345
6239, -144.95778, 48.14251, -192.75423
6240, -144.52287, 54.691857, -192.55708
6241, -59.131039, 27.359323, -89.558198
6242, -86.032688, 30, -106.01071
6243, -57.800194, 57.359323, -107.34409
6244, -78.940658, 52.583402, -92.965825
6245, -12.017745, 52.377117, -178.80781
6246, -2.4393309, 52.571244, -175.84499
6247, -8.1399641, 44.948361, -185.41165
6248, -14.544365, 52.377117, -188.29203
6249, -4.9659514, 52.571244, -185.32921
6250, -167.44699, 30, 55.826032
6251, -153.01662, 13.83421, 38.337776
6252, -143.27895, 28.742258, 47.576614
6253, 1028.9792, 30, 75.963734
6254, 1042.1506, 30, 96.342156
6255, 2.188416, 44.951027, -164.27926
6256, -38.657322, 52.960173, 252.27172
6257, -35.616102, 52.960173, 244.69036
6258, -39.746689, 43.279789, 252.07198
6259, -30.142708, 50.319616, 250.32718
6260, 33.272604, 111.4957, -114.07982
6261, 14.201794, 108.59801, -121.15691
6262, 45.885968, 78.012242, -112.96433
6263, -207.70274, 30.647784, 158.10555
6264, -199.82471, 25.391448, 157.8958
6265, -199.23607, 25.157384, 165.31534
6266, -28.238565, 8.3116925, -263.86382
6267, -21.004734, 8.3116925, -261.0448
6268, -18.553307, 8.3116925, -267.21927
6269, -4.7495954, 8.8297981, 185.74071
6270, 5.3498684, 8.8297981, 185.38565
6271, -14.492831, 198.11918, -121.08607
6272, -196.18073, 45.003536, -45.109114
6273, -202.83726, 37.701698, -39.210741
6274, -202.12707, 52.698162, -46.534946
6275, -202.98092, 38.108198, -52.06581
6276, -193.5694, 7.8024873, -179.38667
6277, 1034.6943, 30, 120.74029
6278, 325.67809, 30, -92.913527
6279, 14.828353, 51.304277, -187.23222
6280, 5.2925427, 52.571244, -184.24902
6281, 19.931204, 37.82535, -196.74586
6282, 1164.7193, 45.007877, 93.048029
6283, -3.9122868, 131.97281, 120.91737
6284, -185.68346, 13.184987, 88.064841
6285, -170.82712, 14.711463, 99.493437
6286, -178.64836, 30.08355, 99.125315
6287, -175.24096, 27.896449, 85.745678
6288, 285.92138, 30, 154.04907
6289, 232.35793, 30, 171.64018
6290, 256.79381, 30, 207.58419
6291, 1040.578, 44.999368, -28.692845
6292, 1009.0937, 30, 91.196377
6293, -179.07815, 8.2705299, -206.0391
6294, -194.33018, 15.019876, -210.78309
6295, -180.56895, 7.7037121, -194.49269
6296, 25.482575, 54.456359, 254.91762
6297, 34.144569, 49.336144, 256.3562
6298, -54.677767, 330, -107.18711
6299, -177.25695, 52.001941, -217.26771
6300, -163.27789, 52.001941, -214.02355
6301, -172.25287, 52.001941, -203.81204
6302, -7.9351112, 16.67028, -264.15531
6303, -21.048676, 8.3116925, -274.687
6304, -245.95918, 16.078129, 32.715048
6305, -242.04157, 21.404469, 35.176568
6306, -261.42552, 16.973848, 18.765104
6307, -256.99966, 16.165621, 25.459342
6308, -199.42684, 36.181268, -159.67408
6309, -198.0769, 37.740666, -152.13821
6310, -198.56937, 43.476174, -153.32827
6311, 38.090567, 49.336144, 265.59926
6312, 21.84477, 9.6751585, -265.50742
6313, 43.899972, 49.336144, 257.33715
6314, 69.494988, 88.565865, -99.900649
6315, 79.138745, 65.155171, -93.750556
6316, 25.825979, 27.669484, 254.95421
6317, 23.798814, 20.7727, 257.83658
6318, -221.12749, 14.814472, -129.4466
6319, -228.6993, 14.814472, -145.05592
6320, -235.76426, 14.814472, -130.47162
6321, -196.25979, 7.8024873, -168.71641
6322, -197.86176, 7.0334427, -160.91647
6323, -206.82108, 9.4259505, -162.06258
6324, -198.51222, 17.228438, -168.18545
6325, -200.11419, 16.459393, -160.38551
6326, 32.304254, 39.650467, 246.92401
6327, 43.143922, 53.416099, 240.3242
6328, 54.310977, 53.416099, 241.06086
6329, 47.61552, 53.416099, 250.21756
6330, 37.860117, 53.416099, 249.23661
6331, -123.30398, 27.840305, -251.97142
6332, -134.75276, 14.815575, -252.15002
6333, -105.93057, 13.02473, -245.55302
6334, -114.69436, 29.849779, -232.51829
6335, -126.14314, 16.825049, -232.69689
6336, -194.3419, 53.829667, -145.89538
6337, -181.91581, 14.989068, 221.28123
6338, -174.65945, 16.722056, 204.59748
6339, -195.33282, 8.0497968, 173.56397
6340, -193.0195, 7.7648669, 180.64883
6341, -73.860021, 12.719601, -157.58904
6342, -73.028615, 30.072786, -146.56948
6343, -90.390701, 14.836138, -168.98934
6344, -87.319469, 17.353185, -148.16414
6345, -89.559296, 32.189323, -157.96978
6346, 1120.3009, 15.020902, -68.337235
6347, -151.47031, 9.4782499, -124.74869
6348, -235.15591, 44.402929, 105.37086
6349, -257.12352, 44.402929, 102.15019
6350, -119.46525, 116.84031, 22.753413
6351, -110.7941, 99.760415, 50.271431
6352, -119.46525, 83.540307, 22.753413
6353, -187.16179, 7.8202759, 185.9678
6354, -161.07973, 7.0229359, 122.29241
6355, -161.60669, 10.648317, 115.03611
6356, -173.31864, 7.0229359, 127.80964
6357, -163.90721, 17.671253, 124.0419
6358, -173.8456, 10.648317, 120.55335
6359, -173.74702, 17.585822, 125.88236
6360, -168.39987, 22.995942, 125.07653
6361, -174.27398, 21.211203, 118.62606
6362, -178.23967, 22.910511, 126.91698
6363, -151.58829, 44.433758, 206.75107
6364, -146.74883, 38.255826, 199.2506
6365, -158.5273, 40.544124, 197.79171
6366, -200.92399, 9.362995, 184.70642
6367, 28.003241, 37.087717, 201.225
6368, 32.962378, 44.755512, 209.82195
6369, 25.81326, 52.39071, 201.50794
6370, 40.237813, 37.06181, 204.73469
6371, 33.088695, 44.697007, 196.42068
6372, -19.171687, 23.333199, -283.93268
6373, -36.110931, 44.613981, 160.37479
6374, -23.695758, 44.955299, 138.43868
6375, -54.613307, 44.613981, 154.99935
6376, -42.198135, 44.955299, 133.06324
6377, -36.807071, 29.56928, 150.58723
6378, -126.60095, 34.852177, -168.4901
6379, -127.45948, 42.153918, -174.82274
6380, -122.45657, 45.746948, -168.3962
6381, -116.88291, 40.24433, -171.72817
6382, 764.61915, 30, 137.21707
6383, 548.84976, 30, 159.83359
6384, 133.63832, 30, 56.280476
6385, 143.60802, 30, 18.916593
6386, 178.34818, 30, 51.506199
6387, -51.515012, 52.960173, 251.78965
6388, 210.51592, 30, 28.587904
6389, 151.71765, 30, 91.862084
6390, 1267.793, 30, -62.130116
6391, 31.914685, 32.358483, 247.69798
6392, -214.32697, 15.345686, 104.13535
6393, 753.89731, 30, 69.161948
6394, 770.79814, 30, 96.364544
6395, 780.72962, 30, 61.458841
6396, 52.269295, 25.09582, 231.99839
6397, 43.214777, 27.469016, 226.73186
6398, 49.367178, 29.59071, 237.95061
6399, 50.588435, 32.364094, 232.20156
6400, 40.31266, 31.963906, 232.68408
6401, 55.609941, 10.100371, 224.01029
6402, 65.052607, 13.541431, 215.69097
6403, 43.080668, 16.553716, 219.31025
6404, 54.338302, 23.641802, 218.20937
6405, 52.523333, 19.994776, 210.99093
6406, 797.7341, 30, 89.002595
6407, 798.56982, 30, 39.787891
6408, 997.05103, 30, 37.825754
6409, 1003.1035, 30, 15.284956
6410, 1018.6421, 30, 32.01103
6411, 506.58329, 30, -153.73098
6412, -127.95426, 36.418592, -176.01778
6413, 14.621531, 34.630753, -187.60325
6414, 11.256888, 36.784958, -193.2411
6415, 817.9229, 30, -83.22539
6416, 25.567811, 30.400081, -284.15697
6417, 14.834646, 36.274935, -285.86355
6418, 18.622242, 44.931947, -290.23586
6419, 24.456426, 36.811121, -270.44461
6420, 28.244021, 45.468133, -274.81693
6421, 17.510857, 51.342987, -276.5235
6422, -194.99349, 15.410036, -69.758739
6423, -181.48091, 16.267973, -84.286651
6424, -220.06699, 32.891246, 39.483955
6425, -261.53445, 30.297449, -41.316742
6426, -251.27394, 29.239768, -39.455744
6427, -252.47792, 22.780711, -50.295932
6428, 434.11684, 30, -63.108214
6429, 21.430536, 51.342987, -265.87496
6430, 32.1637, 45.468133, -264.16839
6431, -123.52151, 54.584174, -163.10765
6432, -98.514336, 47.353185, -130.54007
6433, -85.594953, 47.353185, -130.47059
6434, -97.581025, 47.353185, -141.33535
6435, 801.07192, 30, -36.110433
6436, 801.68978, 30, -66.838556
6437, -255.62377, 14.259227, -54.296188
6438, -264.92364, 9.5791652, -43.636876
6439, -261.68713, 7.5600431, -24.045879
6440, -264.66164, 9.5791652, -35.083503
6441, -259.15913, 38.932348, -33.691066
6442, -2.0310245, 101.73784, -122.95333
6443, 9.7792759, 51.342987, -286.04721
6444, 401.76393, 30, 58.633962
6445, 433.3885, 30, 61.483571
6446, 426.35119, 30, 27.041497
6447, -56.37026, 117.66443, 109.00654
6448, -55.488062, 78.118362, 109.36183
6449, 51.652437, 8.4620259, 252.12918
6450, 60.666698, 14.995449, 246.2881
6451, 50.628692, 23.457475, 243.30918
6452, 454.83113, 30, 95.637915
6453, 690.25811, 30, -77.962625
6454, -115.357, 200.77386, -32.985359
6455, -14.11083, 16.9609, -192.77546
6456, -20.779736, 17.273955, -196.19265
6457, -18.538331, 9.2182109, -194.54752
6458, -216.07851, 49.646506, -152.89966
6459, -212.42036, 49.646506, -166.68736
6460, -206.0533, 49.646506, -158.95346
6461, 766.31993, 30, -98.777486
6462, 735.53123, 30, -73.473079
6463, 728.84584, 30, -102.42878
6464, 27.382356, 23.351764, -259.7358
6465, 37.620123, 23.138518, -260.05925
6466, 31.262759, 22.512536, -249.62603
6467, 41.806604, 48.674771, -225.78228
6468, 36.941866, 52.47, -225.50234
6469, 471.64302, 30, 167.71422
6470, -18.348552, 105.23702, -121.17548
6471, -37.48028, 107.09783, -114.09193
6472, -26.59205, 125.58526, -118.84683
6473, -8.3014088, 9.0335504, -269.07644
6474, -110.40236, 43.381781, 100.19545
6475, -109.99894, 43.381781, 114.71283
6476, -227.47405, 34.704484, -162.8295
6477, -206.7066, 37.693754, -168.69199
6478, 33.576221, 24.019733, -219.70878
6479, 34.787335, 26.651809, -225.61357
6480, -191.36171, 40.716238, -184.19338
6481, -191.05117, 37.688867, -202.84218
6482, -194.84895, 33.500365, -181.20027
6483, -194.53841, 30.472993, -199.84908
6484, 417.28304, 30, 95.782803
6485, 257.06618, 30, 28.18206
6486, 236.90669, 30, 69.460486
6487, 230.6754, 30, -12.690523
6488, -196.89147, 53.829667, -156.57508
6489, -203.50373, 49.646506, -148.27376
6490, 68.944402, 30, -101.59574
6491, 36.293558, 15.468133, -283.19898
6492, 54.517872, 15.468133, -279.75364
6493, -27.487825, 50.730606, -273.49949
6494, -18.401918, 50.730606, -268.28823
6495, -27.910869, 50.730606, -263.26443
6496, -235.82136, 45.057977, -160.02251
6497, 102.20442, 30, -267.61731
6498, 246.13656, 30, 122.27857
6499, 1015.0391, 30, 59.884237
6500, -2.5159477, 50.741623, -264.20963
6501, -18.115324, 35.752112, -284.31099
6502, 32.72213, 15.468133, -263.73642
6503, 31.031238, 15.468133, -273.9514
6504, 43.785909, 15.468133, -267.00679
6505, -1.9456904, 44.951027, -154.30329
6506, -37.546257, 337.4008, 116.70496
6507, 12.33252, 280.45193, -122.27364
6508, 815.5743, 30, 67.331645
6509, 49.546247, 276.83449, 112.57648
6510, 28.959867, 272.1306, 118.42709
6511, -195.14024, 54.58788, -173.43608
6512, -197.77429, 54.58788, -162.55123
6513, -198.42758, 42.635128, -172.28976
6514, -202.39466, 48.047248, -182.82364
6515, -205.0287, 48.047248, -171.9388
6516, -38.788158, 48.578462, -190.37708
6517, -29.583238, 48.578462, -186.26354
6518, -31.686164, 48.578462, -195.89767
6519, 9.2218922, 280.63092, 121.94274
6520, -86.383856, 307.03173, 86.784725
6521, 6.6045302, 6.8364535, -182.95714
6522, 4.4987423, 14.645818, -189.83285
6523, -0.10056365, 6.8364535, -189.07992
6524, 14.377396, 44.389398, -193.78519
6525, -5.7960067, 29.775173, -271.10554
6526, -14.991542, 41.472228, -269.62668
6527, -8.1556773, 35.763129, -285.10357
6528, -25.10551, 40.955579, -189.92641
6529, -22.196106, 52.377117, -184.7116
6530, -24.299031, 52.377117, -194.34573
6531, 14.042664, 29.847547, -195.93389
6532, 21.356902, 24.990427, -196.00875
6533, 16.047229, 21.79583, -186.86615
6534, 9.0600483, 21.13584, -193.14887
6535, -73.949626, 14.963149, -275.88393
6536, -35.040217, 7.5, -234.0652
6537, -35.746196, 14.949586, -236.55028
6538, -37.237459, 14.244849, -225.16051
6539, -40.786413, 7.4495856, -242.61547
6540, -42.277676, 6.7448488, -231.22571
6541, -42.983656, 14.194434, -233.71079
6542, -179.85451, 52.66899, -194.87302
6543, -248.71258, 53.821837, 29.821121
6544, -238.80262, 53.821837, 34.452416
6545, -4.6871761, 6.8364535, -182.19199
6546, -5.9331565, 14.951027, -163.14178
6547, -6.1888282, 14.951027, -145.85655
6548, -5.7511447, 32.278964, -163.18262
6549, -22.633916, 17.327936, -149.7218
6550, -86.925798, 17.353185, -112.68469
6551, -58.693304, 44.712508, -114.01808
6552, -186.00347, 52.460347, -117.15782
6553, -191.72221, 48.471143, -108.73822
6554, -178.21283, 49.600825, -113.08073
6555, -139.54037, 25.243832, -201.83493
6556, -201.12723, 21.191094, 30.609305
6557, -32.160523, 41.221986, 211.77172
6558, -37.623233, 45.615772, 212.42304
6559, -31.665547, 46.957416, 210.5778
6560, -129.89976, 53.828268, -177.61682
6561, -119.32319, 51.91868, -174.52225
6562, -138.08257, 52.708256, 188.65696
6563, -196.68372, 15.003536, -34.17561
6564, -161.30676, 46.267973, -93.789669
6565, -169.13932, 46.267973, -75.848008
6566, -152.00867, 46.267973, -80.114616
6567, -239.59518, 50.718283, -51.844581
6568, 114.32054, 30, 87.744401
6569, 92.029239, 30, 112.0115
6570, 78.71356, 50.579012, 93.408821
6571, 85.264796, 20.579012, 82.158358
6572, -47.491818, 60.435322, 113.43794
6573, -28.989441, 60.435322, 118.81337
6574, -262.18973, 20.549512, 1.7195314
6575, -272.13156, 30.525475, 2.717834
6576, -266.48082, 25.616985, 10.246349
6577, -275.1264, 24.58655, 6.3098044
6578, -110.72722, 51.439043, 158.38263
6579, -116.56214, 51.439043, 163.6924
6580, -116.87087, 43.811885, 158.91938
6581, -113.93698, 52.372842, 151.67997
6582, -119.7719, 52.372842, 156.98974
6583, -183.44954, 37.021817, -211.7812
6584, -193.86425, 45.019876, -211.00578
6585, -18.742877, 152.71888, -121.08694
6586, -56.985941, 155.56822, -106.20863
6587, -49.136769, 182.70184, -108.44875
6588, -79.034634, 163.07516, -94.140087
6589, -275.90864, 15.545737, 63.191477
6590, -263.23625, 15.545737, 54.266973
6591, -256.72675, 15.545737, 70.39257
6592, -141.40431, 30, -13.152135
6593, -146.43893, 11.810549, -26.193739
6594, -139.89344, 30, -28.130383
6595, -155.03462, 41.810549, -13.041604
6596, -153.52375, 41.810549, -28.019852
6597, -286.38786, 32.650472, 28.940016
6598, -278.22578, 34.6287, 39.901359
6599, -287.59102, 47.796474, 19.249807
6600, -279.42893, 49.774701, 30.21115
6601, 77.551697, 43.541431, 196.04077
6602, 76.246402, 43.541431, 227.90374
6603, 78.549926, 13.541431, 202.27775
6604, -134.1808, 28.093244, 99.361182
6605, -123.96999, 28.289829, 86.873915
6606, -120.73792, 35.709488, 101.37405
6607, -150.17381, 29.61951, 84.687008
6608, -146.94174, 37.039169, 99.187145
6609, -136.73093, 37.235754, 86.699878
6610, 31.69912, 49.336144, 248.08343
6611, -197.41342, 10.418945, -83.347994
6612, -258.30176, 15.614647, -19.624679
6613, -251.01575, 16.576088, -28.801305
6614, -253.89961, 8.0546036, -24.248188
6615, -9.6251915, 7.7953111, 193.73607
6616, -177.12974, 45.259182, 18.614589
6617, -185.19868, 45.259182, 13.102788
6618, -189.21147, 45.259182, 24.634282
6619, 40.612265, 20.592564, 213.24154
6620, 38.272188, 21.150353, 204.11477
6621, 37.618753, 28.836226, 205.26451
6622, 51.869898, 27.68065, 212.14066
6623, 49.529822, 28.238438, 203.0139
6624, -193.03414, 30.435, 15.964324
6625, -196.71192, 30.105809, 20.947674
6626, 33.813276, 8.4620259, 246.04791
6627, 37.973368, 8.4620259, 253.40016
6628, 28.337073, 6.1255536, 252.83555
6629, -108.92243, 47.065692, 133.60949
6630, 60.131842, 334.70389, 106.30916
6631, -176.07918, 16.267973, -95.973995
6632, -157.67348, 8.9092367, -106.36649
6633, -169.45798, 25.177209, -104.09407
6634, -158.36858, 16.267973, -94.82329
6635, -160.72466, 11.810549, -13.460791
6636, -165.3532, 11.810549, -28.456597
6637, -108.03533, 7.7704234, -191.11745
6638, -104.70783, 22.606561, -179.42811
6639, -120.55592, 22.479052, -188.8206
6640, -95.958027, 14.836138, -190.48432
6641, -111.80612, 14.708628, -199.8768
6642, -108.47862, 29.544766, -188.18746
6643, -159.89477, 25.746223, -104.88231
6644, -148.11027, 9.4782499, -107.15473
6645, -50.82374, 8.5554837, 213.22129
6646, -44.322262, 8.5554837, 196.06984
6647, -47.890957, 26.706586, 207.48857
6648, -59.928565, 18.151103, 215.67176
6649, -53.427088, 18.151103, 198.52032
6650, -8.4422718, 50.741623, -269.0808
6651, -4.9905948, 50.741623, -276.75008
6652, 1141.0367, 45.020902, -92.249208
6653, 1135.3281, 45.020902, -72.372195
6654, 1150.0881, 45.020902, -72.372195
6655, -191.60189, 15.453117, -182.32864
6656, -202.43493, 18.047248, -182.80569
6657, -196.81646, 25.849735, -178.25831
6658, 391.92887, 30, 25.819086
6659, -14.950241, 50.730606, -275.95751
6660, -3.2329351, 9.0335504, -264.89584
6661, -53.693329, 10.178043, 223.54553
6662, -157.74508, 43.83421, 20.350592
6663, -270.39201, 48.214065, -21.71818
6664, -266.15685, 48.214065, -38.686737
6665, -261.44044, 48.214065, -28.490674
6666, -268.8398, 29.243187, -79.38476
6667, -277.68732, 14.983961, -77.566478
6668, -265.35616, 52.75994, -12.001943
6669, -272.92771, 51.339087, -11.361361
6670, -265.17953, 51.339087, -2.7663145
6671, -169.49606, 44.711463, 96.380085
6672, -154.34321, 44.711463, 94.066617
6673, -159.01204, 44.711463, 105.60255
6674, -89.840623, 14.17346, 168.2824
6675, 47.557274, 6.4533455, 200.25711
6676, 34.189317, 57.571708, 118.13954
6677, 17.939991, 57.571708, 120.76554
6678, 27.60816, 75.180844, 119.64685
6679, -258.3773, 30.15284, -101.21242
6680, -267.38721, 44.983961, -90.273706
6681, -73.842106, 44.17346, 152.01174
6682, -66.913314, 44.233218, 133.17437
6683, -86.907555, 44.17346, 158.7254
6684, -50.847055, 213.25109, 108.67557
6685, -173.66911, 46.134418, 7.4813263
6686, -181.73805, 46.134418, 1.9695248
6687, -110.7416, 45.834565, 178.82831
6688, -109.20022, 30, 258.25781
6689, -206.74343, 30.179028, 170.54997
6690, -205.60481, 19.124804, 172.56624
6691, -203.47885, 29.780214, 183.42385
6692, -103.165, 43.754471, 232.53707
6693, -86.462454, 45.265688, 232.74642
6694, -74.23424, 30.561956, 231.47621
6695, -34.553722, 52.486008, 223.50901
6696, -42.05494, 52.486008, 217.41989
6697, 53.466182, 16.460944, 269.61793
6698, 57.293674, 52.364802, 214.65554
6699, 66.585682, 43.541431, 212.93475
6700, 54.488959, 35.906233, 211.61084
6701, 58.641054, 43.541431, 202.60144
6702, -45.575943, 54.47581, 222.92919
6703, -50.999109, 48.151103, 212.88041
6704, -34.393066, 16.055484, 216.51905
6705, -40.149963, 8.5554837, 209.30004
6706, -35.756897, 7.5, 220.78099
6707, -37.262655, 17.678043, 226.84329
6708, -43.019552, 10.178043, 219.62428
6709, -85.859781, 111.21305, 86.338701
6710, -64.902758, 134.55433, 103.16565
6711, 614.96107, 30, -146.69988
6712, 581.14758, 30, -155.2954
6713, -9.7974357, 53.063975, 193.08283
6714, -99.898191, 51.439043, 158.26236
6715, -107.80348, 51.439043, 168.97532
6716, -109.74254, 38.504736, 152.48172
6717, 1214.1868, 30, -120.53745
6718, 1273.9664, 30, -42.107486
6719, -150.61027, 14.433758, 206.91127
6720, -162.38874, 16.722056, 205.45238
6721, -158.89251, 7.013102, 197.93854
6722, -162.60159, 23.735158, 198.65954
6723, -32.450055, 15.15528, 274.96702
6724, -36.570894, 30.592996, 270.90993
6725, 1291.7165, 30, -80.901523
6726, -9.6764022, 7.6367298, -261.43992
6727, -184.03405, 8.2705299, -219.36612
6728, 48.538076, 34.331593, 245.30387
6729, 52.253624, 38.411548, 238.18428
6730, 41.148748, 42.752244, 246.02007
6731, 54.449411, 39.877044, 250.92291
6732, 1286.0286, 45.821482, -16.978698
6733, 1298.3919, 45.821482, -29.782142
6734, -20.54389, 31.397841, 189.37995
6735, -10.269909, 37.618032, 193.25764
6736, -10.681759, 30.608317, 184.52282
6737, 44.563763, 14.697007, 192.28008
6738, 58.814908, 13.541431, 199.15623
6739, 1299.0135, 15.821482, -29.658818
6740, 1326.1903, 30, -40.962439
6741, -55.200051, 17.273476, -252.5802
6742, -55.128726, 31.599259, -260.91947
6743, -51.305666, 24.723062, -247.58972
6744, -46.134531, 212.33557, -105.35514
6745, -68.164755, 236.04272, -101.08531
6746, 34.545702, 29.565261, 233.21656
6747, 37.447819, 25.070371, 227.26434
6748, 35.766958, 32.338645, 227.46751
6749, -34.832554, 23.243475, 241.98478
6750, -31.417841, 18.927999, 248.06612
6751, -35.759186, 9.3609737, 238.47188
6752, -38.703972, 23.449527, 250.16837
6753, -43.045317, 13.882501, 240.57413
6754, -39.630604, 9.5670256, 246.65547
6755, -42.352439, 35.757332, 262.85496
6756, 1164.802, 15.007877, 93.393433
6757, 1102.2185, 30, 126.98087
6758, 1099.1711, 44.991433, 95.066545
6759, 1091.1864, 30, 98.420323
6760, 1211.2424, 14.951341, 74.980799
6761, 118.4528, 126.39253, 25.717758
6762, 106.00312, 111.36757, 57.969495
6763, 118.4528, 88.592528, 25.717758
6764, 1269.5757, 44.999537, -17.250895
6765, 1263.1193, 44.999537, -36.519798
6766, -114.3588, 48.053732, -133.41813
6767, -102.33253, 35.406917, -140.02264
6768, -61.483166, 43.358952, -188.89406
6769, -81.748198, 44.836138, -188.09218
6770, -122.88683, 45.834565, 196.19817
6771, -30.259439, 18.107152, -195.05951
6772, -27.068059, 27.796673, -189.14959
6773, -45.487933, 22.247893, -191.84846
6774, -42.296554, 31.937414, -185.93854
6775, -35.684023, 27.467404, -197.38826
6776, -41.538815, 52.145807, -197.75703
6777, -34.436821, 52.145807, -203.27762
6778, -35.2433, 40.724269, -198.8583
6779, -153.33207, 25.644759, -1.5648604
6780, -286.17059, 51.339087, -4.4038376
6781, -272.94486, 51.339087, 4.2964958
6782, -171.71017, 8.2705299, -199.85867
6783, -200.098, 25.960712, -162.58657
6784, -207.37775, 27.473198, -171.60447
6785, -198.40224, 34.582009, -172.65942
6786, 66.880198, 103.09339, 100.39452
6787, 72.776821, 132.65689, 97.360783
6788, 88.584681, 108.02665, 85.283396
6789, -113.33651, 43.02473, -240.28405
6790, -132.48573, 44.708628, -197.17532
6791, -159.34346, 47.367367, -39.403191
6792, -171.98825, 47.367367, -34.502016
6793, 65.703378, 316.44836, -100.36493
6794, -48.257611, 43.358952, -173.40497
6795, -51.991963, 42.719601, -161.20279
6796, 83.517444, 30, 167.93149
6797, 105.63504, 30, 167.94555
6798, 1178.6985, 14.938971, -75.001387
6799, 1159.2666, 29.959873, -87.373583
6800, -197.75746, 52.730413, 163.37845
6801, -204.47975, 50.417219, 172.62867
6802, -205.43906, 50.885974, 160.18424
6803, 1153.4101, 15.021955, 134.31878
6804, 1163.8618, 15.021955, 109.82298
6805, 1039.843, 14.999368, -29.10033
6806, 1035.53, 14.965455, -11.415623
6807, -204.40624, 39.047267, -146.00354
6808, -216.66908, 34.215232, -137.83472
6809, -202.05535, 28.722927, -136.40001
6810, -219.99404, 34.460978, -147.53782
6811, -205.38031, 28.968673, -146.10311
6812, -217.64316, 24.136638, -137.93429
6813, -191.75741, 34.370761, -138.15379
6814, -191.75741, 41.870761, -138.15379
6815, -185.45031, 44.930347, -133.45962
6816, -186.28195, 52.460347, -126.36396
6817, -178.49131, 49.600825, -122.28688
6818, 50.144289, 53.235757, -239.84019
6819, 51.915503, 37.975839, -247.35662
6820, 48.405469, 37.564217, -233.44504
6821, 115.92425, 26.82, -19.763184
6822, 783.90235, 30, -128.78773
6823, 724.0882, 30, -143.22755
6824, -219.62997, 45.16888, -113.32895
6825, -232.38523, 29.983351, -122.92028
6826, -219.50163, 44.814472, -129.77767
6827, 42.648417, 53.235757, -233.05503
6828, 49.640783, 44.32846, -223.39469
6829, -31.045139, 42.801361, 248.47168
6830, -104.97396, 13.754471, 232.66851
6831, 832.05169, 30, 83.860875
6832, -202.05129, 9.3221668, -138.7586
6833, -214.08557, 9.3221668, -143.62121
6834, -206.51376, 9.3221668, -128.01189
6835, 55.519901, 174.08367, -107.4253
6836, 22.206686, 147.25008, -118.90017
6837, -277.64644, 30.399736, 54.017656
6838, -281.94287, 14.853999, 46.884697
6839, -61.294069, 45.296268, 249.19521
6840, -63.268594, 45.296268, 237.13075
6841, -106.80864, 47.065692, 145.24231
6842, -31.043208, 52.79513, -247.38853
6843, -31.664531, 46.630579, -246.19438
6844, -38.974309, 52.79513, -246.03594
6845, 66.548387, 13.235288, -212.973
6846, 63.821022, 17.406141, -200.53473
6847, 56.135118, 14.32846, -211.90833
6848, 73.497009, 30.641429, -213.47578
6849, 63.08374, 31.734601, -212.41111
6850, 1033.8073, 14.965455, 17.493206
6851, 1031.3722, 44.965455, 16.052088
6852, 1038.5711, 45.369521, 33.225867
6853, 31.081158, 45.627128, -246.38632
6854, -72.724637, 45.265688, 227.36067
6855, -77.906023, 45.265688, 216.36542
6856, -140.32595, 52.47, -189.60212
6857, -96.929324, 29.225556, -128.90287
6858, -98.662882, 27.628596, -147.68038
6859, -112.77379, 29.926103, -131.78093
6860, -109.10414, 22.147782, -139.43867
6861, -52.192877, 44.613981, 168.93143
6862, -212.75355, 49.400761, -143.19655
6863, -67.399568, 45.92583, -212.02792
6864, -63.389184, 31.104149, -214.54088
6865, -81.178028, 45.92583, -217.97583
6866, -66.855483, 45.178319, -199.90234
6867, -80.633943, 45.178319, -205.85025
6868, 57.428866, 11.970914, -182.72006
6869, 69.472416, 17.406141, -187.38463
6870, 70.268241, 14.875405, -168.70242
6871, -134.21458, 7.6795458, -136.92974
6872, -126.99332, 16.211283, -131.49557
6873, -137.629, 23.890828, -130.64617
6874, -142.17312, 7.6795458, -129.05646
6875, -206.97007, 39.223653, -30.041663
6876, -201.02373, 31.529027, -28.615831
6877, -207.20433, 47.281771, -30.310303
6878, -201.25799, 39.587145, -28.884471
6879, 800.50477, 30, 127.21496
6880, -210.35992, 52.391067, 33.633818
6881, -216.0089, 54.659508, 37.34479
6882, 83.2531, 17.406141, -205.83288
6883, -121.29745, 13.83421, 11.476744
6884, -114.91684, 13.83421, 35.389629
6885, -191.48366, 7.6789811, -2.4082735
6886, -191.91172, 7.7961204, -10.244015
6887, -116.38432, 234.86187, -24.317445
6888, -105.61262, 266.86673, -63.043726
6889, 72.956364, 44.281687, 177.2758
6890, 73.954593, 14.281687, 183.51278
6891, 59.185634, 27.823118, 191.12508
6892, 52.657442, 30.910076, 218.41254
6893, -198.41016, 31.996369, -152.91077
6894, -208.40235, 29.072457, -158.61913
6895, -199.08132, 21.775814, -155.82326
6896, -196.05928, 21.67203, -143.30724
6897, -206.05147, 18.748117, -149.0156
6898, 1275.4079, 45.821482, -7.481998
6899, 1133.9561, 44.991433, 73.32367
6900, -176.84648, 46.267973, -99.977205
6901, 29.520128, 54.660393, 207.15437
6902, 68.132029, 14.740082, -271.18855
6903, 72.747537, 14.740082, -253.93156
6904, -184.38772, 11.804628, -110.2064
6905, -178.46162, 28.072601, -106.78328
6906, -177.76653, 20.713865, -118.32648
6907, -52.307562, 6.7448488, -227.96139
6908, -62.036737, 15.92583, -230.1341
6909, -51.874595, 6.7448488, -213.6793
6910, -54.204093, 22.670679, -224.49374
6911, -61.603771, 15.92583, -215.85202
6912, 18.591009, 6.1255536, 261.18836
6913, 29.794047, 14.647146, 262.65109
6914, -167.40057, 46.267973, -105.40447
6915, -171.51943, 35.868797, -105.6544
6916, -168.76692, 49.600825, -118.508
6917, -123.1633, 52.327707, 100.02141
6918, -194.32204, 49.792233, 132.23423
6919, -194.01032, 35.00858, 129.88261
6920, -192.6192, 52.47, 139.65436
6921, -202.49314, 45.216347, 136.94997
6922, -192.30748, 37.686347, 137.30274
6923, 39.353379, 308.66557, -115.96402
6924, 41.189982, 282.00211, -115.15371
6925, -38.622798, 38.178327, 215.94377
6926, 1211.2424, 44.951341, 119.9808
6927, 1231.5042, 29.948458, 67.104553
6928, 1226.1879, 44.951341, 70.99292
6929, -195.0852, 31.750624, -143.20766
6930, -194.75194, 37.49492, -142.4351
6931, -232.46384, 52.47, 35.85757
6932, -238.5191, 50.159882, 42.314041
6933, -261.9526, 54.58266, 17.055055
6934, -255.23651, 44.357361, 26.575913
6935, -266.81457, 49.774701, 23.646479
6936, -265.18018, 53.074072, 11.21157
6937, -258.46409, 42.848773, 20.732428
6938, -164.22148, 46.134418, -1.3925217
6939, -200.17877, 49.400761, -138.57065
6940, -203.91383, 49.400761, -128.24338
6941, -193.87167, 52.460347, -133.87648
6942, -197.60672, 52.460347, -123.54921
6943, -240.89904, 13.927631, -77.546154
6944, -255.27249, 14.259227, -75.307862
6945, -244.80999, 15.16888, -97.135522
6946, -239.06511, 28.186858, -65.054533
6947, -228.60261, 29.096511, -86.882193
6948, -242.97606, 29.428106, -84.643901
6949, 41.977849, 38.01136, 238.6668
6950, 38.262302, 33.931405, 245.78639
6951, -103.66037, 286.77411, 65.278086
6952, -170.91489, 39.796519, 196.8252
6953, -164.5021, 41.304992, 198.67315
6954, -168.18382, 53.074463, 195.944
6955, -281.33257, 24.007335, 37.458771
6956, -282.58432, 9.1533369, 27.224878
6957, -283.03495, 24.223574, 20.166832
6958, 24.943511, 52.391371, -254.633
6959, 35.275457, 53.235757, -251.35205
6960, -217.60284, 45.16888, -96.077565
6961, -216.20905, 33.640023, -108.27223
6962, -217.26583, 25.587825, -98.572559
6963, -161.16337, 36.737734, -104.26178
6964, -158.41086, 50.469762, -117.11539
6965, -152.31705, 50.469762, -105.50058
6966, -99.184028, 39.271865, -151.2231
6967, -185.90698, 11.804628, -121.99986
6968, 87.918191, 150.84909, 86.003134
6969, -288.09024, 32.866711, 11.648077
6970, 862.93741, 30, -119.71161
6971, 84.048925, 14.875405, -187.15067
6972, -130.94648, 40.79565, -180.29413
6973, -132.16692, 37.178628, -190.00675
6974, -133.38676, 52.47, -183.08821
6975, -169.20504, 54.658757, -126.11289
6976, -173.3239, 44.259581, -126.36282
6977, -178.92943, 54.658757, -129.89177
6978, 285.33619, 30, 55.351386
6979, 302.15598, 30, 3.4194803
6980, 324.7147, 30, 37.431927
6981, 273.88597, 30, -23.749846
6982, 88.594544, 154.58018, -84.755241
6983, 105.39648, 134.28159, -48.276739
6984, 91.503713, 104.81676, -82.050945
6985, 78.38998, 337.78279, -93.457591
6986, -91.640327, 30, -217.10061
6987, -111.37475, 44.708628, -203.43257
6988, -104.59229, 14.708628, -211.24799
6989, -73.851483, 15.178319, -213.66566
6990, -93.585902, 29.886948, -199.99762
6991, 367.36409, 30, 100.23384
6992, 33.522502, 262.45404, -116.15022
6993, -129.80649, 27.314501, 139.83129
6994, -131.26213, 19.817508, 136.92881
6995, -126.06496, 22.740142, 147.01279
6996, -94.526452, 338.72598, 78.662619
6997, -103.81923, 314.28331, 65.078365
6998, 737.52942, 30, 41.567687
6999, 742.47388, 30, 1.7618529
7000, -136.79875, 32.851138, -193.15886
7001, -76.945809, 45.92583, -234.44995
7002, -92.220071, 43.02473, -243.80394
7003, -79.20753, 28.95056, -236.02044
7004, -96.452289, 43.02473, -227.32981
7005, -107.25817, 33.161788, -178.47484
7006, -119.33547, 26.096074, -179.10798
7007, -43.669384, 36.842675, 245.2611
7008, -43.537235, 40.848772, 237.64347
7009, -74.395568, 15.92583, -225.79124
7010, 294.54719, 30, 105.63837
7011, 333.9257, 30, 87.718911
7012, -92.691972, 52.583402, -80.842412
7013, -122.39552, 44.06307, -96.88601
7014, -133.22542, 44.06307, -80.950305
7015, -102.88302, 36.646472, -78.17865
7016, -126.57709, 41.119932, -144.79251
7017, -121.82559, 53.0662, -146.10521
7018, -24.389967, 174.09365, 119.10312
7019, -13.628239, 222.9335, 122.15105
7020, 50.128232, 48.199439, -214.59474
7021, 50.947742, 52.438139, -208.00883
7022, 65.552619, 47.406141, -208.28111
7023, 55.345258, 35.60558, -207.35115
7024, -228.14521, 24.483928, -165.74199
7025, -196.58284, 41.113554, -178.69861
7026, -274.97666, 47.796474, 12.685136
7027, -264.59437, 44.413159, 1.3824448
7028, -266.62617, 40.870546, 9.7710852
7029, -274.39085, 39.135561, 2.8560115
7030, -147.24335, 17.157796, -126.64704
7031, -150.16307, 24.654502, -125.17154
7032, -117.42818, 7.7704234, -188.48133
7033, -74.667578, 14.233218, 124.4481
7034, -199.68083, 52.391067, 25.252557
7035, -31.052031, 53.129764, 209.40043
7036, -40.570729, 53.129764, 210.82491
7037, -36.035867, 19.539016, 232.78456
7038, -43.321997, 24.060544, 234.88681
7039, -44.24863, 10.178043, 231.3739
7040, -53.44844, 29.17877, 242.66666
7041, -53.316291, 33.184867, 235.04903
7042, -54.99914, 38.256442, 243.84072
7043, -108.53245, 130.87339, 44.281182
7044, -117.67375, 149.27896, 27.759116
7045, -194.03661, 9.3221668, -129.74181
7046, -194.8998, 21.126795, -128.75763
7047, -192.73149, 16.822167, -138.25336
7048, -183.73867, 7.5, -131.49559
7049, -184.60185, 19.304628, -130.51141
7050, -32.375586, 8.5554837, 209.00545
7051, -30.727932, 15.577621, 206.69455
7052, 57.127346, 53.416099, 227.43996
7053, -186.91509, 52.759268, 189.37526
7054, -184.03787, 45.490156, 192.75581
7055, -195.65461, 43.176487, 179.23874
7056, -192.77738, 35.907375, 182.6193
7057, -44.373006, 52.145807, -206.69611
7058, -47.719021, 51.052475, -214.01494
7059, -56.798578, 45.178319, -204.78464
7060, -41.339972, 43.198281, -213.55708
7061, -50.419528, 37.324126, -204.32677
7062, -53.765543, 36.230794, -211.64561
7063, -229.4662, 44.993167, 178.43015
7064, -208.88962, 50.417219, 183.11534
7065, -225.19405, 35.410386, 176.72239
7066, -235.1535, 44.993167, 165.50434
7067, -214.57692, 50.417219, 170.18954
7068, -38.074725, 54.47581, 229.01831
7069, -127.62755, 30.673894, -175.26244
7070, -109.40425, 27.733359, -221.47719
7071, -116.66486, 46.825049, -214.47368
7072, -30.674102, 9.5670256, 249.55674
7073, -34.606556, 9.5670256, 256.73337
7074, -26.865116, 7.9634942, 253.87469
7075, 1140.5153, 15.020902, -92.331982
7076, -57.472782, 28.537271, -191.40702
7077, -50.860251, 24.067261, -202.85674
7078, -47.668871, 33.756782, -196.94682
7079, 885.29836, 30, -125.90445
7080, 314.80916, 30, 188.77127
7081, 74.902021, 267.01626, 94.051485
7082, 93.416567, 289.07953, 79.949206
7083, 81.331961, 226.77697, 85.746744
7084, 99.846507, 248.84023, 71.644465
7085, -36.985974, 7.5, 232.53061
7086, -101.92473, 92.400117, 68.830917
7087, -204.67279, 24.321743, 201.28891
7088, -193.97132, 30.448904, 200.48436
7089, -278.40029, 16.321523, -6.3948927
7090, -279.69654, 27.327921, -1.4600453
7091, -275.40545, 22.260448, -9.9868631
7092, 42.256133, 8.4620259, 262.72039
7093, 34.076812, 14.647146, 271.97131
7094, 59.893845, 212.75367, 103.67861
7095, 72.110331, 175.47933, 98.080521
7096, 44.389909, 44.697007, 195.72528
7097, 61.71196, 28.53688, 223.67907
7098, 36.519153, 54.660393, 217.75503
7099, -286.794, 21.860313, 6.7132295
7100, -291.36413, 24.601684, -1.0566203
7101, -116.38432, 278.06187, -24.317445
7102, -123, 219.42, -9.184851e-15
7103, -210.1307, 27.953009, 46.408086
7104, -209.3915, 13.295627, 56.997393
7105, 885.99161, 30, 139.5889
7106, -192.18392, 45.849395, -25.479328
7107, 123, 150.72, -1.2858791e-15
7108, -99.861298, 113.7935, 71.7992
7109, 366.95778, 30, 50.543886
7110, -77.737814, 30.014457, -190.60514
7111, -95.526657, 44.836138, -194.04009
7112, 1226.1879, 14.951341, 70.99292
7113, 536.66289, 30, -161.70645
7114, 1018.2687, 14.965455, 0.76713207
7115, -15.314103, 9.2182109, -185.52279
7116, -7.7814579, 7.742689, -191.47742
7117, -11.016549, 16.054664, -183.49004
7118, -3.4839035, 14.579142, -189.44467
7119, -32.379472, 23.283331, -282.84994
7120, -31.323109, 35.702245, -283.22825
7121, 26.538122, 14.951027, -147.232
7122, -152.31877, 21.203655, -197.54286
7123, 4.2014877, 30.416781, -271.34964
7124, 13.579066, 31.018146, -272.21561
7125, 5.8003403, 25.080833, -265.11195
7126, -3.4330429, 36.147298, -264.18156
7127, 5.9445357, 36.748662, -265.04753
7128, 103.94215, 299.32567, 49.954734
7129, 123, 291.54, -1.2858791e-15
7130, -12.373143, 37.286606, -260.51607
7131, -61.26247, 47.273476, -239.47565
7132, -58.629633, 47.273476, -255.33015
7133, -75.538645, 47.273476, -246.15617
7134, -77.079996, 47.273476, -267.64323
7135, -77.800365, 30.298207, -247.72665
7136, -93.761422, 43.02473, -265.291
7137, -178.6619, 10.508074, -128.1587
7138, -170.52145, 19.417311, -124.48532
7139, -33.495962, 52.79513, -254.72231
7140, -215.67783, 48.233864, 37.217976
7141, -207.00244, 31.529491, 34.810479
7142, -201.68454, 35.686694, 31.226321
7143, -105.33201, 212.30894, 62.767302
7144, -186.55159, 31.680804, 211.65554
7145, -179.80453, 46.722056, 217.70933
7146, -49.074838, 8.8889414, -204.16788
7147, -36.090096, 8.8889414, -198.70073
7148, -191.75335, 7.5, -140.51238
7149, -29.395699, 16.944685, -204.43132
7150, -26.610393, 8.0557437, -199.83387
7151, -27.474133, 9.2182109, -190.46206
7152, -218.03496, 24.753244, 177.80015
7153, -215.909, 35.408654, 188.65776
7154, -86.130178, 47.353185, -151.56678
7155, 85.487615, 324.88567, 87.784163
7156, 68.060793, 298.89775, 98.474201
7157, 43.103986, 8.4620259, 243.32669
7158, -51.593783, 13.882501, 249.15816
7159, -46.275134, 29.320218, 256.04408
7160, -48.17907, 9.5670256, 255.2395
7161, -42.860421, 25.004742, 262.12541
7162, 1277.7225, 44.481298, 44.263972
7163, 1254.1034, 44.997117, 53.710802
7164, 112.47441, 281.29386, 29.994472
7165, 1193.9385, 14.938971, -75.001387
7166, 1188.8951, 14.938971, -91.361308
7167, -61.059686, 15.178319, -203.72644
7168, -144.85538, 14.711463, 97.927047
7169, -158.14724, 14.711463, 91.132406
7170, -159.58192, 14.711463, 105.23044
7171, -51.575522, 39.389481, -242.68348
7172, -62.526104, 33.199306, -238.37267
7173, -246.23824, 14.402929, 83.389791
7174, -270.34603, 14.99694, 84.69799
7175, -194.07312, 53.06506, -10.405412
7176, -197.30412, 54.583609, -16.261308
7177, -153.22867, 24.119517, 107.55726
7178, -137.69943, 9.4080543, 108.31003
7179, -152.42596, 9.4080543, 115.61343
7180, -41.67516, 15.63379, -212.8096
7181, -33.228819, 18.274788, -209.74951
7182, -39.461417, 22.989493, -210.38593
7183, -36.028577, 16.130696, -219.26093
7184, -42.261174, 20.8454, -219.89735
7185, -33.814834, 23.486398, -216.83726
7186, -215.53623, 50.885974, 157.74512
7187, -134.09982, 27.579785, 133.67798
7188, -143.88255, 24.84832, 128.19325
7189, -137.1077, 19.932056, 131.67267
7190, -146.89043, 17.200591, 126.18794
7191, -136.28998, 21.547574, 123.42498
7192, -98.826143, 51.91868, -165.64531
7193, -102.25526, 36.754818, -172.0483
7194, -35.827912, 21.707113, -231.19114
7195, -34.629677, 26.556117, -237.06577
7196, -35.827912, 29.177113, -231.19114
7197, -80.519139, 334.37679, -92.168311
7198, -77.494452, 297.8173, -94.298015
7199, -100.06968, 292.58165, -70.654263
7200, -37.342993, 43.522475, -224.43796
7201, -37.342993, 36.022475, -224.43796
7202, -36.264918, 43.552592, -218.85405
7203, -60.638762, 116.66542, -102.45798
7204, -2.3683067, 14.163444, 142.57592
7205, -13.681901, 14.163444, 154.91898
7206, 10.941566, 79.151214, 120.79067
7207, -51.99035, 30.026381, -222.07007
7208, -51.446265, 29.278871, -209.94449
7209, -53.660009, 21.923168, -212.36816
7210, 33.133356, 34.909584, 239.57075
7211, 36.019802, 43.730422, 239.80442
7212, 37.29677, 7.5, 232.75156
7213, -225.94309, 44.402929, 84.120041
7214, -157.55817, 35.315032, -123.62126
7215, -156.34599, 42.860754, -123.60063
7216, -162.52972, 40.070586, -117.36531
7217, -167.91423, 34.446095, -125.01388
7218, -166.70205, 41.991817, -124.99324
7219, -43.416772, 29.297421, -284.69122
7220, -128.63728, 46.211283, -129.71316
7221, -136.18147, 52.672657, -134.94286
7222, -164.93184, 33.250684, 198.64277
7223, -127.8756, 45.045732, 148.85709
7224, -116.05077, 52.372842, 140.04715
7225, -122.09602, 52.372842, 147.54899
7226, -226.13307, 30.588668, 128.09126
7227, -227.12054, 15.345686, 115.09568
7228, -216.35442, 30.45933, 139.03662
7229, -231.51489, 15.242982, 130.47932
7230, -217.34189, 15.216347, 126.04105
7231, -150.06331, 50.913431, 117.51315
7232, -101.73411, 25.111549, -168.50558
7233, -178.25224, 13.295627, 47.728337
7234, 1268.7574, 14.999537, -21.284573
7235, 1260.2448, 14.997159, -35.392935
7236, 1279.5722, 45.821482, -36.247601
7237, -142.52351, 44.06307, -94.625359
7238, -142.38012, 34.532832, -105.09747
7239, -140.56076, 50.469762, -114.85323
7240, -130.76722, 44.06307, -103.978
7241, 150.70658, 30, 185.78428
7242, 189.5623, 30, 168.59075
7243, -242.07765, 15.166305, -41.340713
7244, -245.69179, 17.905453, -32.664522
7245, -244.28575, 22.657204, -39.176891
7246, 110.37209, 216.78637, 41.649993
7247, 1150.8959, 30, -99.836798
7248, 1141.053, 30, -125.21448
7249, -125.23207, 34.295212, 111.27178
7250, -38.43468, 31.034748, -204.76821
7251, -31.726545, 24.516969, -207.04768
7252, -39.020694, 36.246358, -211.85596
7253, -31.285822, 37.773834, -208.51771
7254, -32.312559, 29.728578, -214.13542
7255, -38.801293, 29.013353, -242.83846
7256, -38.719578, 22.255825, -248.19759
7257, -48.532851, 32.079715, -250.68676
7258, -41.574108, 21.656699, -239.74141
7259, -51.387381, 31.48059, -242.23058
7260, 46.526856, 140.55954, 112.19942
7261, -110.07887, 52.583402, -46.045774
7262, -238.91353, 14.402929, 72.830593
7263, -249.40204, 15.545737, 59.833372
7264, 706.28863, 30, 24.681004
7265, -33.94564, 36.600669, -217.15293
7266, -42.366709, 35.153026, -219.17479
7267, -32.918903, 44.645924, -211.53522
7268, -12.346746, 14.955299, 112.32532
7269, 1.9757179, 42.527007, 110.18582
7270, 102.71283, 30, 138.4808
7271, 136.14823, 30, 159.20808
7272, -31.505339, 23.117932, -259.68606
7273, -27.830577, 31.351222, -250.95376
7274, -30.448976, 35.536845, -260.06437
7275, -54.651753, 25.474311, 233.46643
7276, -63.819772, 15.296268, 231.32538
7277, -54.375072, 15.296268, 239.15375
7278, -117.2083, 10.275411, -147.99766
7279, -113.03081, 10.275411, -158.90161
7280, -128.99279, 7.7992395, -142.77243
7281, -124.81529, 7.7992395, -153.67638
7282, -50.8163, 7.4495856, -239.35115
7283, -60.629573, 17.273476, -241.84031
7284, -50.988889, 14.325782, -283.53504
7285, -44.937942, 14.325782, -274.11692
7286, -61.028436, 14.325782, -266.52462
7287, -26.204319, 26.634206, -198.52141
7288, -22.888058, 33.963846, -196.28974
7289, -17.463474, 24.603595, -193.96098
7290, -221.25582, 15.16888, -112.99788
7291, -104.60711, 27.9843, -261.28417
7292, -84.731343, 27.987879, -267.92655
7293, 78.289324, 79.595039, 93.882717
7294, -51.47309, 47.273476, -245.20045
7295, -48.620158, 40.068606, -250.91438
7296, -39.076741, 44.911135, -243.51897
7297, -221.44663, 13.927631, -79.776167
7298, -232.30686, 13.927631, -64.966962
7299, -35.290768, 52.47, -223.6007
7300, -42.633761, 51.052475, -220.03865
7301, -34.212692, 52.500117, -218.01679
7302, 100.58063, 79.595039, 69.61562
7303, -170.97479, 38.704607, 127.03755
7304, -163.4439, 37.136736, 125.68497
7305, -195.11321, 14.958748, 210.07965
7306, 909.42274, 30, 124.31472
7307, -94.798055, 13.02473, -264.94865
7308, -28.535165, 34.206489, -201.13776
7309, 35.414668, 53.416099, 240.96384
7310, -113.83619, 60.42, 35.924873
7311, -14.256672, 47.327936, -168.14451
7312, -33.305495, 47.327936, -166.72954
7313, -24.435033, 47.327936, -174.0483
7314, -132.33969, 7.5, -181.91452
7315, -128.39613, 15.270423, -181.2474
7316, -129.03919, 7.5, -189.66748
7317, 16.792444, 54.456359, 262.48858
7318, -37.237459, 6.7448488, -225.16051
7319, -162.51893, 29.968628, 10.084222
7320, -33.900642, 8.3116925, -272.27564
7321, 24.914896, 7.8836307, -254.73418
7322, 24.312231, 25.143292, -270.50904
7323, 13.019745, 24.839801, -263.75181
7324, 13.16394, 36.50763, -263.68738
7325, -79.636066, 17.353185, -131.41422
7326, 6.4192936, 254.60696, -122.83187
7327, -109.01519, 126.93631, -43.613605
7328, 356.2564, 30, -45.847266
7329, -100.81752, 44.836138, -181.98408
7330, -39.287746, 52.145807, -212.71982
7331, -38.4537, 48.578462, -178.94478
7332, -27.344438, 35.906399, -179.26311
7333, 11.485923, 15.305809, -183.55012
7334, -266.92237, 9.1533369, 37.708088
7335, -269.98669, 9.1533369, 21.191219
7336, 4.3869838, 51.342987, -277.61605
7337, -139.34944, 37.142014, 201.98577
7338, -138.08257, 37.678256, 188.65696
7339, -142.37103, 40.787605, 191.65481
7340, -99.494288, 10.275411, -158.69994
7341, -270.07111, 15.943413, 14.828559
7342, -117.63671, 34.344675, 155.80303
7343, -112.95229, 39.438534, 145.77906
7344, -127.9167, 12.139519, 113.79476
7345, -118.65156, 13.381781, 100.11395
7346, -117.24211, 25.5213, 115.2289
7347, -108.69422, 13.381781, 110.62147
7348, -97.177058, 112.38148, -75.178131
7349, -146.97815, 14.06307, -79.854687
7350, -127.09758, 14.06307, -83.075193
7351, -139.58533, 14.06307, -95.65898
7352, -19.680927, 31.595328, -187.59766
7353, -15.500925, 37.762501, -194.7378
7354, -179.1024, 32.139858, 129.26716
7355, -184.97651, 30.355119, 122.8167
7356, -184.13639, 34.762233, 132.58701
7357, -183.27367, 25.532886, 130.23683
7358, -7.4434582, 30, -122.64437
7359, 5.1961754, 14.951027, -127.65845
7360, 15.84518, 39.552575, -126.49658
7361, -36.099608, 14.613981, 175.17733
7362, -49.540318, 14.613981, 179.81247
7363, -37.294841, 14.613981, 163.28314
7364, -124.14926, 27.146814, 155.07111
7365, -184.43362, 47.367367, -39.149585
7366, -18.884287, 9.2212673, 196.15944
7367, -25.625294, 7.0221369, 202.46115
7368, -22.746377, 16.243404, 199.341
7369, -288.20239, 47.796474, 3.9848028
7370, -287.86686, 33.163479, -4.5374651
7371, -168.53323, 52.128699, 111.58243
7372, 1062.8527, 30, -90.42551
7373, 1045.8954, 30, -70.594911
7374, -27.106012, 42.993466, 254.06207
7375, -26.016645, 52.673851, 254.26181
7376, 79.243841, 13.541431, 227.09443
7377, 52.118247, 14.995449, 237.4856
7378, -0.32950038, 35.226871, 170.07004
7379, -2.4254368, 44.163444, 162.33552
7380, 10.237652, 37.065339, 176.80367
7381, 8.1417152, 46.001912, 169.06915
7382, -267.17746, 33.287003, 6.6297575
7383, -18.390778, 47.327936, -158.16854
7384, -83.700075, 13.02473, -253.3318
7385, 32.23682, 34.01456, -243.7366
7386, 29.524926, 30.619778, -248.15729
7387, 28.662102, 38.168997, -249.05512
7388, -149.33249, 14.815575, -241.75497
7389, -248.39155, 24.153396, -31.154545
7390, -256.27674, 33.845976, -25.389868
7391, -248.14822, 36.350195, -32.834667
7392, -114.40431, 30.42, -13.152135
7393, -148.29745, 43.83421, 11.476744
7394, -121.29745, 44.25421, 11.476744
7395, -124.04227, 14.79368, -171.72917
7396, -116.00452, 7.7704234, -169.82415
7397, -120.72868, 7.7704234, -180.72837
7398, -123.26167, 7.0232566, -161.49206
7399, -127.98583, 7.0232566, -172.39629
7400, -40.851627, 28.307665, -225.92798
7401, -52.794546, 30.132943, -230.52437
7402, -43.065371, 20.951962, -228.35165
7403, -110.29915, 7.7704234, -179.83264
7404, -61.548415, 270.63297, -106.0527
7405, -227.5319, 45.242982, 151.2232
7406, -231.43821, 45.242982, 133.41112
7407, -242.02848, 45.242982, 151.92905
7408, -125.34567, 52.39121, 161.14893
7409, -3.7914712, 22.050502, -182.75724
7410, 4.1716844, 20.162929, -183.47526
7411, 5.1521608, 21.787481, -169.73831
7412, 1.7503112, 30.165075, -172.33631
7413, 9.7134669, 28.277502, -173.05433
7414, -190.91059, 22.779024, 202.55029
7415, -188.57803, 17.183271, 186.70149
7416, -140.90033, 52.327707, 96.079487
7417, -14.694777, 32.541985, -176.20155
7418, -10.378892, 39.899181, -174.74835
7419, -26.278014, 41.30238, -198.58726
7420, -150.65226, 37.437964, 126.15611
7421, -6.6321762, 43.924288, -263.63379
7422, -142.08978, 36.353697, 129.72086
7423, -145.56916, 52.327707, 107.61542
7424, -151.4359, 35.624894, 109.08487
7425, -10.971484, 45.166859, 169.91763
7426, -10.542411, 29.330303, 163.37714
7427, -8.8755481, 36.230287, 177.65214
7428, -126.71675, 54.660281, 167.76523
7429, 35.375916, 6.4533455, 204.04705
7430, 32.382404, 14.697007, 196.07002
7431, 305.37284, 30, -40.581108
7432, 327.93156, 30, -6.5686611
7433, 98.973146, 45.665973, -230.83434
7434, 88.954075, 33.072114, -215.61083
7435, 91.68144, 28.901261, -228.04909
7436, 21.409458, 14.931947, -289.37033
7437, 47.912447, 27.97447, -230.14609
7438, -57.342662, 45.92583, -216.91022
7439, 34.000927, 24.158657, -238.162
7440, 66.585819, 138.32928, -102.60494
7441, 40.22355, 8.4393393, -212.93896
7442, 47.219311, 8.4393393, -203.94203
7443, -53.964386, 45.178319, -195.84556
7444, -192.30748, 30.186347, 137.30274
7445, -18.890882, 45.101035, -197.03533
7446, 46.976069, 53.235757, -254.70046
7447, 57.47847, 44.740082, -258.9517
7448, 38.301347, 38.70389, -255.92171
7449, 48.803747, 30.208215, -260.17295
7450, -32.490457, 8.8889414, -208.25818
7451, 32.571997, 20.777263, -212.02126
7452, 38.570446, 20.121148, -215.53963
7453, 104.31476, 45.665973, -201.06348
7454, -11.474939, 6.8364535, -173.56271
7455, 3.0699772, 6.8364535, -171.14808
7456, -165.88895, 29.177916, -37.466547
7457, -120.87795, 18.053732, -140.33992
7458, -115.47474, 11.872371, -129.22015
7459, -178.36184, 15.259182, 23.874668
7460, -270.67373, 14.983961, -91.876381
7461, -2.7446388, 45.323249, -190.62984
7462, 0.57785518, 52.571244, -190.22508
7463, -9.1490397, 52.752005, -193.51022
7464, 59.104334, 338.66557, -106.68527
7465, -154.07457, 10.535204, -198.13585
7466, -13.721308, 60.435322, 119.60553
7467, -16.454211, 52.377117, -195.25218
7468, -12.323052, 45.129122, -193.59266
7469, 37.432148, 53.416099, 233.45024
7470, -122.10349, 22.623655, -165.29317
7471, 101.43753, 15.665973, -220.4062
7472, 115.34092, 15.665973, -254.31375
7473, 128.42147, 15.665973, -215.37585
7474, -14.432983, 44.923046, 286.8323
7475, -18.430383, 30.078326, 286.74241
7476, -194.17479, 48.047248, -192.35697
7477, -279.91651, 45.367073, -53.352317
7478, -283.29936, 33.58107, -23.282925
7479, -281.04731, 33.581137, -40.911846
7480, -282.62796, 48.214065, -30.550944
7481, -198.35894, 50.885974, 154.95692
7482, -204.67047, 50.885974, 147.91016
7483, -262.88637, 28.21953, -1.8970603
7484, -270.09976, 34.068088, -5.6708063
7485, 1276.4328, 14.481298, 46.859495
7486, 1297.3182, 44.481298, 32.518744
7487, 1266.3935, 30, 65.769617
7488, 1285.9892, 30, 54.024389
7489, 1085.8132, 30, -122.96785
7490, -286.40372, 45.367005, -18.754837
7491, 1044.4987, 30, -119.37884
7492, -195.24441, 43.230428, -143.62516
7493, 31.656341, 27.326179, -179.51207
7494, 38.458393, 18.856823, -173.3791
7495, -200.01364, 17.811606, 161.42379
7496, -181.4352, 53.074463, 194.57883
7497, 16.287747, 44.563729, 287.05301
7498, 28.923876, 44.563729, 288.72512
7499, -48.782674, 30, -112.34642
7500, -67.28755, 17.353185, -110.11635
7501, -40.188429, 57.359323, -116.24815
7502, -67.983188, 47.353185, -139.37465
7503, -61.131191, 30, -133.6443
7504, 10.825882, 53.259627, 265.78951
7505, -192.49047, 7.5, 139.96568
7506, 167.37493, 30, -237.09723
7507, 203.71752, 30, -225.80652
7508, -200.80571, 50.417219, 180.8867
7509, 1254.6067, 44.997159, -50.62816
7510, 68.279984, 43.235288, -220.71937
7511, -47.825833, 38.39789, 257.21814
7512, -38.19599, 34.202117, 250.89792
7513, -123, 331.92, -9.184851e-15
7514, -116.00164, 331.92, -31.635066
7515, -37.262655, 25.148043, 226.84329
7516, 4.1543267, 43.734247, 191.58313
7517, 9.0423094, 52.67082, 192.54962
7518, 6.2253449, 51.063427, 185.31153
7519, 0.71580493, 51.063427, 191.1726
7520, -134.49721, 33.05295, 124.95259
7521, -131.08892, 34.812409, 137.20358
7522, -158.10153, 29.061285, 197.62933
7523, -119.26408, 42.139519, 128.39364
7524, -4.1971541, 24.439225, -264.86785
7525, 40.57129, 41.910528, -235.83263
7526, -25.445772, 54.59923, -254.01832
7527, -15.936822, 54.59923, -259.04211
7528, 38.312824, 23.448012, -249.91172
7529, 49.496447, 30.517709, -250.02542
7530, 38.501025, 29.423637, -242.47523
7531, -153.78599, 17.626687, -226.20627
7532, 51.777472, 11.970914, -195.87017
7533, -215.87073, 53.827982, -34.325968
7534, -12.455849, 37.591165, -186.86486
7535, -14.418398, 24.432259, -186.08804
7536, -6.8857531, 22.956737, -192.04267
7537, -16.591823, 43.913271, -262.84122
7538, -10.042553, 53.182665, -262.29534
7539, 1317.37, 14.481298, 27.655173
7540, -188.26895, 13.184987, 74.491884
7541, -216.66614, 45.242982, 141.38824
7542, -217.26521, 45.216347, 128.97285
7543, -143.33098, 44.433758, 211.91546
7544, -131.19716, 52.708256, 200.97434
7545, -126.15754, 52.372842, 152.85142
7546, -99.784002, 30, -93.887292
7547, -96.036213, 41.872371, -122.22888
7548, -237.61252, 43.927631, -75.943479
7549, -225.35758, 15.16888, -99.365535
7550, -124.29237, 34.265015, -134.05636
7551, -152.14762, 31.430437, -71.536067
7552, -151.36983, 30.331043, -93.386559
7553, -152.78646, 47.367367, -58.264124
7554, 45.501542, 81.070057, 114.00305
7555, 125.00413, 30, 114.2137
7556, -7.6674801, 280.45193, -122.27364
7557, 32.743787, 27.617599, 240.34471
7558, -217.83104, 45.345686, 96.776666
7559, -227.04386, 45.345686, 118.02748
7560, -212.07383, 45.345686, 112.35854
7561, -122.52191, 48.053732, -138.55751
7562, 93.758254, 44.404063, 265.21132
7563, 54.219575, 14.281687, 180.39126
7564, -140.54872, 31.387535, -129.17067
7565, -134.41545, 31.656341, -133.46569
7566, -31.682668, 74.511337, -118.6679
7567, -260.5089, 22.957861, -16.322831
7568, -261.38449, 28.126819, -9.5161386
7569, -247.23142, 8.5214843, -31.893872
7570, -150.90506, 29.948012, -116.59322
7571, 14.37523, 51.342987, -263.05811
7572, -94.501114, 17.353185, -137.83798
7573, -106.67593, 10.275411, -148.37378
7574, -67.018648, 17.273476, -255.68403
7575, -151.43167, 35.646014, -124.55101
7576, -169.4398, 44.670931, -195.64845
7577, -166.81243, 37.193049, -196.94271
7578, -172.18848, 11.810549, -18.578021
7579, -210.10985, 10.418945, -91.466532
7580, -68.946524, 45.296268, 266.10013
7581, -116.42011, 13.381781, 82.892338
7582, -132.41311, 14.908047, 68.218164
7583, -134.64457, 14.908047, 85.43978
7584, -252.98008, 52.731763, -25.364036
7585, 1120.9365, 44.991433, 86.625046
7586, -80.770204, 45.921808, 203.781
7587, -92.480365, 45.265688, 213.48882
7588, -152.82989, 50.469762, -124.10357
7589, -129.67781, 46.211283, -119.47288
7590, -103.84301, 334.37679, -63.563048
7591, -156.28956, 24.323521, -124.24179
7592, -165.85278, 23.754507, -123.45355
7593, -199.45218, 44.234387, -159.30442
7594, -211.7329, 7.0875016, -34.631011
7595, -161.62576, 27.17285, 124.05117
7596, -153.46067, 31.561748, 118.89054
7597, -155.25344, 20.056371, 117.36293
7598, -152.44503, 25.932588, 124.62849
7599, -144.27994, 30.321485, 119.46786
7600, -212.05664, 46.526144, -33.914818
7601, -160.46827, 29.378998, -115.80498
7602, -170.82434, 28.510061, -117.1976
7603, -271.19137, 7.5600431, -25.443806
7604, -285.31754, 44.853999, 46.852637
7605, -272.01554, 44.259227, -68.677381
7606, -251.98597, 44.259227, -73.705187
7607, -259.2323, 44.259227, -56.971724
7608, -83.037399, 272.10238, -86.687477
7609, -286.89025, 6.7900757, -2.0416304
7610, -286.70957, 15.070237, 13.075889
7611, -191.57223, 13.184987, 62.476947
7612, -195.05666, 13.295627, 46.185711
7613, -274.16587, 9.5791652, -36.481431
7614, 66.651886, 30, 103.25037
7615, -285.83506, 36.706092, -12.926106
7616, -192.09102, 37.931024, 13.219277
7617, -195.83357, 37.650249, 20.099757
7618, -125.6544, 44.764052, 156.37591
7619, -191.84284, 52.759268, 178.71785
7620, 29.58662, 46.001912, 156.91042
7621, 33.483253, 44.530426, 140.41079
7622, 47.3128, 44.281687, 158.45933
7623, -125.67695, 37.22031, 157.6091
7624, 42.618034, 44.281687, 171.80435
7625, -54.52374, 42.719601, -148.79955
7626, -126.59317, 37.547823, 151.4848
7627, 13.337294, 46.001912, 159.53642
7628, -188.16956, 37.500786, 105.10519
7629, -191.37566, 35.16432, 113.12162
7630, -194.12409, 49.792233, 118.58816
7631, -182.63312, 41.920932, 117.15045
7632, -258.16415, 14.402929, 99.627152
7633, -235.23258, 14.402929, 102.43906
7634, -130.922, 53.0662, -140.44931
7635, -132.69247, 39.277482, -135.94815
7636, -242.89636, 15.242982, 150.5404
7637, -248.64208, 30.181254, 140.36841
7638, -107.32544, 10.275411, -168.9101
7639, -113.81141, 18.045834, -169.13871
7640, 27.208309, 30.698919, 182.70002
7641, 29.74101, 14.697007, 185.22924
7642, 26.571057, 22.217401, 193.23411
7643, -126.29184, 25.852972, -145.33321
7644, -128.30008, 33.49879, -142.31004
7645, -50.631503, 44.613981, 181.9381
7646, -38.981774, 44.613981, 173.57688
7647, 33.63891, 6.4533455, 212.57313
7648, 30.404467, 14.34734, 208.66541
7649, 34.415768, 16.967536, 214.12719
7650, -124.40415, 53.828268, -169.08676
7651, -113.82758, 51.91868, -165.99219
7652, 32.962222, 44.697007, 183.69316
7653, 27.473408, 37.205996, 193.43857
7654, 49.550971, 28.867146, 279.21067
7655, 58.371995, 14.22, 283.52987
7656, 34.787942, 213.74222, 117.70067
7657, 18.703336, 15.414388, 197.78475
7658, 23.674785, 7.5203935, 193.16638
7659, 27.410955, 22.591002, 200.68838
7660, 24.514683, 7.8939943, 200.62066
7661, 1254.0714, 14.997159, -55.415566
7662, 35.766958, 39.838645, 227.46751
7663, 43.199106, 40.784744, 232.91775
7664, 1211.2424, 44.951341, 74.980799
7665, 35.152663, 7.6703851, -255.05763
7666, -23.624925, 35.542326, 256.37854
7667, -29.375359, 35.898972, 251.527
7668, -53.954221, 54.47581, 231.52591
7669, -53.489537, 52.960173, 239.72519
7670, -146.96675, 41.810549, -46.880785
7671, 46.216442, 7.6703851, -258.32799
7672, 57.400066, 14.740082, -258.4417
7673, -261.10808, 33.611882, -19.73478
7674, -258.90094, 26.268668, -23.036628
7675, 991.10561, 30, 69.137894
7676, -249.52517, 35.705619, 52.156437
7677, -250.1045, 39.934583, 38.04014
7678, -245.88277, 50.159882, 48.031871
7679, -259.51915, 35.320438, 47.283635
7680, -255.29742, 45.545737, 57.275366
7681, -29.319872, 21.819919, -249.45839
7682, -32.092687, 14.463265, -246.36135
7683, -135.72907, 13.83421, 43.595037
7684, 47.004429, 176.46788, 112.10258
7685, -35.018206, 35.98082, 223.28357
7686, -33.160088, 33.784541, 215.29244
7687, -34.069076, 30.662319, 220.43476
7688, -128.84799, 27.056872, -184.97505
7689, 99.068188, 324.88567, 71.029486
7690, -17.327067, 52.673851, 262.20693
7691, -14.707776, 37.819227, 265.52989
7692, -21.324467, 37.82913, 262.11704
7693, -33.728716, 7.4495856, -244.06387
7694, -38.074725, 46.94581, 229.01831
7695, -35.927193, 40.358599, 228.42589
7696, 54.045721, 44.281687, 183.83647
7697, 41.166757, 18.856823, -153.61488
7698, 57.371797, 14.875405, -149.40986
7699, 54.663433, 14.875405, -169.17408
7700, -236.17931, 15.057977, -160.3476
7701, -89.669829, 13.02473, -235.14523
7702, -107.00224, 13.02473, -231.85348
7703, -0.94116805, 24.271256, 190.79635
7704, 0.86504273, 29.893225, 183.92568
7705, -0.46884853, 36.504885, 191.21572
7706, -34.155351, 29.780841, 171.74129
7707, -157.81219, 10.535204, -205.57396
7708, -18.8508, 38.701522, 196.7885
7709, -36.03407, 37.601369, -251.52225
7710, 51.04019, 26.299373, -207.74654
7711, 46.482029, 22.767799, -215.81841
7712, -68.049917, 32.236625, -270.27878
7713, 35.213529, 28.61601, -232.25373
7714, 40.756988, 7.6703851, -246.23139
7715, -35.452804, 7.4495856, -252.37536
7716, 4.8415848, 45.656365, -190.802
7717, 40.078267, 32.320781, -232.53367
7718, -43.765217, 6.7448488, -220.46219
7719, 28.615741, 14.647146, 282.97159
7720, -167.92013, 44.711463, 77.552137
7721, 31.585155, 32.933097, 206.54491
7722, 35.706552, 45.705757, -235.55269
7723, -142.08886, 34.967559, -204.19996
7724, 8.695678, 53.085121, -192.60219
7725, 974.57638, 30, 85.615277
7726, 999.78592, 30, 123.88897
7727, -197.09215, 16.35561, -147.86949
7728, -203.48475, 7.0875016, -36.931646
7729, -194.17026, 15.003536, -44.220442
7730, -200.97129, 7.0875016, -46.976478
7731, 36.230737, 20.614562, 221.34563
7732, 35.63285, 13.953346, 220.0459
7733, 31.422256, 25.211198, 206.15016
7734, 28.858767, 29.544108, 202.11275
7735, -204.13069, 9.4259505, -172.73284
7736, -148.37254, 38.82699, -212.12481
7737, 34.979415, 29.109219, 221.19563
7738, -168.76759, 8.9092367, -123.91185
7739, -188.36317, 7.7037121, -185.16409
7740, -202.12439, 15.019876, -201.4545
7741, -211.56103, 18.047248, -179.68094
7742, -213.25679, 9.4259505, -169.60808
7743, -188.97934, 23.930538, -6.1001197
7744, -197.02476, 45.003536, -33.617097
7745, -202.9711, 52.698162, -35.042929
7746, -192.30748, 22.716347, 137.30274
7747, -183.27367, 18.062886, 130.23683
7748, -195.06245, 43.295627, 35.760846
7749, -183.68541, 10.562886, 122.3938
7750, -36.016053, 44.586005, -231.64404
7751, -36.016053, 37.086005, -231.64404
7752, 952.43044, 30, 117.16726
7753, -285.67468, 24.94617, -30.9086
7754, -277.50436, 19.110612, -27.83118
7755, -275.12904, 27.745512, -20.205505
7756, -262.25181, 40.974005, -16.530031
7757, -269.82335, 39.553152, -15.889448
7758, -261.93166, 52.731763, -18.591542
7759, -258.8273, 40.945828, -23.11963
7760, -98.550882, 93.253456, -73.189169
7761, -210.8782, 52.698162, -33.300807
7762, -32.026451, 52.145807, -209.68724
7763, -222.78494, 40.099911, -35.372174
7764, -213.2513, 40.790809, -34.409959
7765, -221.59028, 45.835246, -34.877033
7766, -158.58721, 54.583829, 122.64928
7767, 3.3591197, 16.507991, 191.09038
7768, 0.24348542, 8.8297981, 190.75323
7769, -4.4828728, 16.625109, 191.50167
7770, -231.52975, 14.657382, 54.674187
7771, -241.06753, 30.203119, 56.240747
7772, -242.04768, 9.0658456, 50.530193
7773, -251.58547, 24.611583, 52.096753
7774, -236.11556, 24.035846, 36.396787
7775, -248.42906, 50.159882, 37.682747
7776, -173.74873, 42.740901, 114.59361
7777, -120.74727, 39.738582, 142.41942
7778, -179.01845, 7.8202759, 195.49223
7779, -166.74774, 7.8202759, 196.34713
7780, -170.45683, 24.542332, 197.06812
7781, -37.138587, 38.822083, 209.34879
7782, -36.653917, 35.119337, 202.23137
7783, -46.567402, 41.280867, 207.88356
7784, -35.654352, 42.556782, 198.71064
7785, -46.082732, 37.578121, 200.76613
7786, -201.46698, 27.79331, -123.28624
7787, -217.7715, 24.491046, -121.48557
7788, -216.79742, 34.56964, -121.386
7789, -198.50626, 13.184987, 84.940082
7790, -190.85491, 52.47, -140.424
7791, 1173.7533, 30.029832, 101.73204
7792, -13.26404, 45.240549, 193.79469
7793, -16.605156, 52.176574, 195.20839
7794, -28.999732, 24.722305, 265.03423
7795, -17.84338, 30.37799, 264.43351
7796, -21.258292, 23.118774, 262.17555
7797, 52.590383, 216.60373, -109.7397
7798, -164.22754, 35.323665, 108.61374
7799, -172.24921, 25.274349, 108.82039
7800, -169.90582, 36.840162, 103.15415
7801, -176.09212, 31.175089, 120.25986
7802, -181.7704, 32.691585, 114.80027
7803, -110.44226, 51.91868, -175.23741
7804, -42.542639, 29.132022, -261.52734
7805, -202.42581, 7.0230414, -26.628456
7806, -149.77942, 9.4080543, 125.08735
7807, -141.60744, 7.792537, 129.23022
7808, -140.78972, 9.4080543, 120.98253
7809, -197.79217, 22.872436, -22.099987
7810, -193.36248, 23.645515, -15.462284
7811, -197.99612, 7.7961204, -19.990753
7812, -253.08204, 21.49196, 27.920862
7813, -250.69878, 43.450047, -30.564428
7814, 62.983599, 14.995449, 229.47999
7815, 14.690451, 24.607106, -285.92797
7816, -6.6074611, 29.915386, 287.55767
7817, -10.887283, 30.14762, 274.634
7818, -34.781277, 29.886641, 256.97926
7819, -33.298053, 29.461858, 244.71612
7820, -26.967908, 15.15528, 286.09463
7821, -18.683021, 15.15528, 274.04011
7822, -191.72657, 30.702182, 8.5865829
7823, 1245.084, 44.951341, 76.567846
7824, -227.92545, 44.477263, -36.280502
7825, -255.27159, 18.219182, 35.537868
7826, -249.97525, 32.113324, 30.36345
7827, -252.1648, 28.840547, 37.980456
7828, -154.72648, 16.43099, 124.61922
7829, -124.27494, 22.48603, 165.86447
7830, -123.23304, 26.819301, 161.19541
7831, -192.78065, 9.362995, 194.23085
7832, -267.56406, 30.943066, -16.027626
7833, -158.25666, 44.907353, 241.61022
7834, -196.18289, 32.374886, -20.478062
7835, -131.00699, 12.139519, 126.46726
7836, -127.26547, 7.5651605, 133.64875
7837, -104.94237, 11.872371, -129.59627
7838, -35.120189, 40.213953, -236.75024
7839, -216.53741, 15.242982, 141.69955
7840, -62.14342, 60.435322, 104.95836
7841, 696.62146, 30, -137.51052
7842, -146.64215, 43.83421, 27.146935
7843, -173.51756, 32.212212, 195.00219
7844, -111.60089, 14.908047, 60.012756
7845, -128.73303, 7.6779888, 142.69947
7846, 1008.815, 30, -120.69272
7847, 982.95728, 30, -82.184882
7848, 967.69304, 30, -116.15433
7849, 1265.5474, 30, 101.53464
7850, 1243.7943, 14.951341, 79.163369
7851, 1244.2378, 44.951341, 112.33287
7852, 1292.81, 30, 78.836358
7853, -166.25231, 31.260519, 118.4194
7854, -170.218, 32.959827, 126.71032
7855, -234.05526, 35.129882, 36.456471
7856, -239.98127, 32.498505, 35.236252
7857, -239.20913, 38.238922, 35.543259
7858, -179.85918, 37.884638, 129.59439
7859, -98.221856, 14.836138, -179.1995
7860, -258.02832, 50.718283, -46.131536
7861, 44.934489, 28.978694, 184.24893
7862, -25.3399, 8.3116925, -283.57326
7863, -135.76187, 7.6779888, 134.48636
7864, 171.20443, 30, 234.48759
7865, 210.06016, 30, 217.29407
7866, -40.8827, 30.047537, -161.52112
7867, -196.41714, 40.433004, -20.746702
7868, -120.23663, 7.5651605, 141.86186
7869, 1001.3497, 30, -34.478395
7870, 1007.2613, 30, -12.182755
7871, 1025.2576, 30, -23.958025
7872, 23.883424, 29.871259, 198.43027
7873, 16.078155, 37.683241, 195.7311
7874, -19.122698, 46.759667, 197.02546
7875, -24.332782, 52.176574, 192.44006
7876, -25.190721, 54.583093, 201.03662
7877, -22.227948, 15.166859, 162.50109
7878, -21.740179, 30.122158, 149.80518
7879, 1252.8137, 14.997117, 56.306324
7880, -10.170107, 15.166859, 171.07855
7881, -112.22831, 290.12486, -38.72628
7882, -116.05589, 14.95957, -261.46277
7883, -155.27881, 41.525633, 120.52433
7884, -193.33059, 10.562886, 130.19536
7885, -127.02485, 22.789835, 109.74417
7886, 12.095479, 14.530426, 132.80992
7887, -162.4094, 25.359779, 106.97994
7888, -35.023715, 29.070551, -222.73684
7889, -226.15336, 35.879142, 164.27797
7890, -62.059704, 29.288931, -281.11937
7891, -65.560611, 44.963149, -275.53005
7892, -50.451396, 44.325782, -283.6302
7893, -201.39182, 54.583609, -24.716659
7894, 98.613784, 30, -191.28553
7895, -181.37534, 16.134418, -6.9289384
7896, -188.63039, 38.806259, 2.0860146
7897, -191.92549, 52.671841, 6.8405828
7898, -101.70835, 13.381781, 94.899834
7899, -123.46182, 44.95957, -256.19381
7900, -102.34539, 44.95957, -259.71369
7901, 35.63285, 6.4533455, 220.0459
7902, -206.00809, 10.418945, -105.09887
7903, -204.95131, 18.471143, -114.79855
7904, 36.450832, 6.4567472, -230.98006
7905, -146.65862, 17.367367, -60.389011
7906, -162.85495, 50.612202, 117.04202
7907, -227.93971, 44.657382, 56.038697
7908, -227.92545, 36.977263, -36.280502
7909, -232.52711, 29.10572, -35.28908
7910, -238.13132, 36.639404, -34.202843
7911, -262.62594, 24.699074, 44.841047
7912, -184.21281, 13.295627, 35.001232
7913, -284.8725, 9.5791652, -39.260459
7914, -241.16003, 29.767631, -32.555814
7915, -277.66474, 30.870534, -9.8486857
7916, 1023.0467, 30, -55.226761
7917, 999.13883, 30, -65.747131
7918, 1022.2412, 30, -86.828534
7919, -268.53217, 39.579165, -46.312413
7920, -240.79916, 44.259227, -62.684769
7921, -236.57, 6.6448204, -42.62262
7922, -236.28004, 6.6448204, -53.773451
7923, 1131.1939, 45.020902, -117.62689
7924, 36.440439, 7.5, -223.01291
7925, 95.107838, 15.665973, -243.21971
7926, 33.814063, 36.911704, -233.79504
7927, 38.743546, 26.638778, -210.75844
7928, -162.39864, 8.0013939, -198.07801
7929, -167.7136, 8.2705299, -207.27248
7930, 1.0774026, 21.069164, -192.76069
7931, -18.828462, 30, -140.84247
7932, -26.985072, 27.359323, -111.64366
7933, -45.046283, 14.955299, 143.28833
7934, -28.05983, 47.712857, 205.72504
7935, -33.269913, 53.129764, 201.13964
7936, -27.57516, 44.010111, 198.60762
7937, -32.785244, 49.427018, 194.02222
7938, -19.957305, 39.705053, -177.71117
7939, -29.028671, 44.869725, -205.96721
7940, -35.023715, 21.600551, -222.73684
7941, 658.44199, 30, -141.36908
7942, -52.712831, 23.375416, -235.8835
7943, -39.581488, 44.325782, -274.96247
7944, 51.419808, 7.6703851, -241.20241
7945, -243.03829, 20.904047, -53.861022
7946, -48.592069, 43.358952, -184.83727
7947, -207.30496, 33.096183, -32.984127
7948, -218.29322, 32.122278, -35.210705
7949, -217.52746, 26.377531, -34.907291
7950, 1224.8779, 44.951341, 89.994084
7951, -130.94648, 33.29565, -180.29413
7952, -172.8519, 10.648317, 109.2991
7953, -182.69171, 10.562886, 111.13956
7954, -38.989435, 36.922244, -243.29136
7955, -41.843964, 36.323119, -234.83518
7956, -34.932048, 32.305062, -236.29735
7957, -32.077518, 32.904187, -244.75352
7958, -25.471535, 52.723918, -203.00658
7959, 34.655876, 41.47269, -241.06779
7960, -34.547961, 19.798589, -242.42491
7961, 20.153878, 9.6751585, -275.72239
7962, -31.775147, 27.155242, -245.52195
7963, 57.866715, 44.32846, -219.65471
7964, -276.69751, 9.531447, -13.192546
7965, -279.63194, 9.531447, -22.814993
7966, -246.68031, 14.259227, -62.72867
7967, 34.162853, 31.882943, -237.76884
7968, 40.920081, 36.881767, -239.80642
7969, -60.886989, 33.447371, 225.59267
7970, 20.746233, 26.381172, 260.43925
7971, -77.310999, 13.02473, -239.48808
7972, -35.290215, 6.7448488, -217.7696
7973, 35.882291, 31.24576, -258.59051
7974, -192.0981, 53.06506, -0.77407348
7975, 84.778204, 30.406055, -240.89601
7976, -59.377387, 48.151103, 221.47713
7977, -70.343033, 33.416791, 215.82259
7978, 133.58424, 30, -245.00668
7979, 125.38182, 45.665973, -220.87708
7980, -132.40721, 24.010522, -136.48886
7981, 114.23508, 45.665973, -254.58175
7982, -116.36176, 28.601061, -168.18544
7983, -71.043563, 15.178319, -195.56415
7984, -181.11454, 47.119103, -130.4399
7985, -90.077326, 11.872371, -123.17252
7986, -192.73149, 24.292167, -138.25336
7987, -236.39735, 50.159882, 51.954388
7988, -12.49799, 44.163444, 152.01063
7989, -43.170905, 35.259588, -227.62909
7990, 1285.2102, 15.821482, -21.012376
7991, -123, 109.77, -9.184851e-15
7992, -245.71967, 8.5214843, -50.20836
7993, -163.80271, 45.196031, 125.66046
7994, 249.20991, 30, -56.886336
7995, -36.274956, 30, -137.00023
7996, -35.837272, 47.327936, -154.32629
7997, -194.39413, 22.223573, -105.84462
7998, -198.38412, 11.804628, -120.26994
7999, -43.605222, 49.427018, 191.47303
8000, 44.744589, 10.100371, 232.0159
8001, -160.71949, 11.810549, -45.785167
8002, -140.83891, 11.810549, -49.005672
8003, -125.07721, 20.118667, -176.2157
8004, -182.84529, 7.5, 132.16411
8005, -222.43901, 14.402929, 91.478727
8006, -93.524238, 151.28427, -78.928784
8007, -50.814396, 76.37215, -111.58434
8008, -194.08341, 52.730413, 171.63648
8009, -231.48288, 14.993167, 175.28718
8010, -203.32546, 48.471143, -115.12962
8011, 1.2219013, 36.364494, -285.96953
8012, 38.994047, 39.013384, -245.77418
8013, -242.17082, 29.225728, 42.853258
8014, -237.79178, 6.6448204, -35.458962
8015, -275.29325, 45.545737, 65.850413
8016, -266.61091, 45.545737, 54.234913
8017, -260.00349, 7.5600431, -17.265532
8018, -92.264103, 79.165172, -81.339411
8019, -78.512789, 79.165172, -93.462825
8020, -41.306821, 52.116005, -227.24474
8021, -185.45031, 52.460347, -133.45962
8022, -217.10761, 9.4259505, -156.13723
8023, -54.518272, 48.151103, 200.64595
8024, 33.762333, 24.653409, 215.27692
8025, -168.51251, 50.612202, 126.14383
8026, -27.303261, 35.951967, 198.37066
8027, -27.787931, 39.654712, 205.48808
8028, -244.49871, 7.0122838, 31.570139
8029, -252.21619, 7.0122838, 26.152403
8030, 52.419952, 37.360251, 225.39986
8031, -141.45461, 53.061155, 131.11231
8032, -220.6652, 24.240422, -150.45031
8033, 1115.3502, 30, -122.08281
8034, -249.20311, 37.853741, 30.670457
8035, -143.3262, 44.908047, 51.770062
8036, 17.236237, 43.734358, -260.90922
8037, 1130.0562, 15.020902, -117.64415
8038, -203.56859, 9.362995, 174.22966
8039, -197.97742, 8.0497968, 163.08721
8040, -196.74906, 17.412792, 174.29766
8041, -0.8018199, 22.993242, 169.65067
8042, 357.12272, 30, 17.72901
8043, 280.69678, 30, -73.717597
8044, -126.39537, 44.908047, 85.521275
8045, -73.903503, 60.435322, 94.121659
8046, -44.089892, 53.129764, 198.59046
8047, 39.396823, 14.281687, 173.34043
8048, -39.2162, 14.971639, -287.04809
8049, -220.18115, 44.991435, 190.36552
8050, -33.859746, 44.971639, -287.89363
8051, 1039.7725, 44.999368, -60.294617
8052, 6.9127669, 36.237679, 192.53392
8053, 10.502751, 43.572416, 187.54222
8054, -242.77064, 9.0658456, 41.648665
8055, -229.85076, 29.748615, 100.051
8056, -244.24773, 30.283958, 124.98478
8057, -252.35977, 29.341201, 112.32815
8058, -249.62956, 14.938272, 127.37284
8059, -137.77584, 46.825049, -208.21642
8060, -217.43745, 29.775016, 94.235364
8061, -3.4629792, 44.127402, 191.75276
8062, -91.744939, 13.381781, 110.78546
8063, -32.164824, 40.893078, -244.98114
8064, 34.354612, 37.682968, 233.8217
8065, -195.93828, 52.671841, 18.372077
8066, 116.60802, 26.82, 18.916593
8067, 79.650772, 13.235288, -241.08465
8068, -26.053097, 7.0136797, -253.63615
8069, -3.4138563, 125.24248, -122.94213
8070, 1036.2649, 44.965455, -11.008138
8071, 61.364176, 44.875405, -152.48207
8072, -230.31901, 6.6448204, -37.452902
8073, -205.07333, 9.4259505, -151.27462
8074, -196.11401, 7.0334427, -150.12852
8075, -81.065313, 15.178319, -202.29448
8076, -71.421676, 44.17346, 165.94382
8077, -192.01169, 10.418945, -95.035339
8078, -260.1855, 9.1533369, 21.572961
8079, -261.5286, 9.1533369, 28.975223
8080, -213.82552, 36.727793, -41.43732
8081, -218.53175, 36.128957, 149.99682
8082, -40.965459, 8.8889414, -210.95077
8083, -255.8819, 9.0658456, 44.963794
8084, -274.52985, 17.09149, -16.793556
8085, -202.56289, 28.142254, 32.074238
8086, -114.96409, 30, 39.583077
8087, -250.48812, 9.0658456, 36.230929
8088, -119.46484, 32.240674, 145.04714
8089, -109.32899, 335.55733, 56.3142
8090, 32.074894, 26.290274, -244.12976
8091, -11.292927, 24.16439, -173.60355
8092, -24.972549, 9.5670256, 265.25559
8093, -17.231109, 7.9634942, 262.39692
8094, 42.427233, 24.23959, 220.45998
8095, -38.739582, 9.5670256, 266.1825
8096, 931.98245, 30, 118.33312
8097, 1018.2687, 44.965455, 0.76713207
8098, 626.24488, 30, 145.23522
8099, -162.76783, 10.535204, -214.28606
8100, -33.683494, 8.5554837, 200.8047
8101, -63.829887, 44.613981, 177.31227
8102, -14.4032, 14.923046, 286.96378
8103, -117.67375, 198.77896, 27.759116
8104, 1326.9264, 30, 34.820068
8105, 1314.2518, 30, 63.734876
8106, 1304.6953, 14.481298, 56.569981
8107, 85.980465, 13.235288, -218.27114
8108, -64.558773, 48.151103, 210.48188
8109, -67.716656, 48.151103, 196.02012
8110, -149.55241, 7.013102, 193.89895
8111, 1037.6321, 14.999368, -60.369066
8112, 28.45928, 24.960411, -206.4643
8113, -223.43372, 28.999631, -36.119033
8114, -240.39404, 43.981719, 35.051317
8115, -250.38802, 43.596538, 30.178515
8116, -253.56107, 54.58266, 26.21852
8117, 1223.8082, 14.951341, 90.789938
8118, 1244.2378, 14.951341, 112.33287
8119, -21.044038, 45.166859, 159.59274
8120, 1289.8438, 14.481298, 30.720406
8121, -202.29518, 45.216347, 123.3039
8122, -6.0204582, 30.21505, 265.24876
8123, 1169.1257, 14.938971, -94.961173
8124, -123, 169.92, -9.184851e-15
8125, 33.596307, 33.275191, -190.0618
8126, 21.935769, 29.773633, -187.67811
8127, -20.65196, 45.021506, -288.97638
8128, -14.652977, 22.628627, 265.54235
8129, -218.55931, 44.657382, 65.963636
8130, -36.340707, 9.2212673, 188.71629
8131, -55.463823, 39.772078, 235.64145
8132, -157.34095, 34.801405, 197.30131
*Element, type=C3D10, ELSET=PART1
1, 335, 1012, 334, 756, 4349, 4348, 1670, 
3068, 4874, 3069
2, 1271, 1067, 775, 1291, 4875, 4879, 4877, 
4876, 4878, 4880
3, 1245, 416, 1246, 1159, 4881, 4885, 4883, 
4882, 4884, 4886
4, 1178, 1275, 1179, 1272, 4887, 4891, 4889, 
4888, 4890, 4892
5, 764, 775, 1271, 39, 3329, 4877, 4893, 
3085, 3106, 4894
6, 227, 819, 228, 686, 3207, 3206, 1548, 
2838, 4895, 2836
7, 905, 926, 902, 895, 4896, 4898, 3833, 
3828, 4897, 3790
8, 1291, 1177, 1271, 1270, 4899, 4902, 4876, 
4900, 4901, 4903
9, 1266, 819, 1171, 686, 4904, 4907, 4906, 
4905, 4895, 4908
10, 1358, 1150, 566, 805, 4909, 4913, 4911, 
4910, 4912, 4914
11, 1080, 1305, 352, 1081, 4915, 4917, 4627, 
4630, 4916, 4628
12, 1150, 1358, 446, 376, 4909, 4919, 3720, 
3721, 4918, 3719
13, 1237, 1166, 818, 1235, 4920, 4924, 4922, 
4921, 4923, 4925
14, 638, 610, 1274, 1275, 2690, 4929, 4927, 
4926, 4928, 4930
15, 481, 592, 289, 916, 2338, 4934, 4932, 
4931, 4933, 4935
16, 494, 1246, 609, 505, 4936, 4938, 2390, 
2204, 4937, 2389
17, 280, 108, 279, 840, 2910, 2907, 1606, 
3426, 4939, 3427
18, 291, 387, 413, 30, 4025, 4941, 4940, 
1619, 1737, 4942
19, 290, 919, 897, 413, 4943, 4945, 3771, 
4944, 3898, 4946
20, 1267, 667, 1266, 452, 4947, 4951, 4949, 
4948, 4950, 4952
21, 1267, 667, 668, 1266, 4947, 2731, 4953, 
4949, 4951, 4954
22, 1266, 819, 881, 1171, 4904, 3653, 4955, 
4906, 4907, 4956
23, 791, 364, 1339, 792, 3138, 4958, 4957, 
3357, 3141, 4959
24, 852, 1279, 697, 1184, 4960, 4963, 3666, 
4961, 4962, 4964
25, 464, 100, 487, 831, 1886, 2156, 2288, 
4965, 4966, 4967
26, 921, 898, 887, 902, 4968, 3801, 4970, 
4969, 3808, 3807
27, 1180, 619, 1182, 521, 4971, 4974, 4973, 
4972, 2411, 4975
28, 1180, 1046, 1181, 1059, 4976, 4979, 4978, 
4977, 4526, 4980
29, 708, 485, 599, 588, 4981, 2364, 4983, 
4982, 2365, 2523
30, 588, 486, 600, 707, 2366, 2367, 2574, 
4984, 4985, 4986
31, 1043, 1180, 1182, 521, 4987, 4973, 4989, 
4988, 4972, 4975
32, 699, 783, 1318, 784, 3545, 4991, 4990, 
3408, 3349, 4992
33, 823, 240, 239, 678, 3218, 1560, 3219, 
4993, 2757, 2756
34, 793, 441, 1341, 1345, 4994, 4998, 4996, 
4995, 4997, 4999
35, 1313, 436, 437, 1316, 5000, 1827, 5002, 
5001, 5003, 5004
36, 769, 1299, 1183, 717, 5005, 5008, 5006, 
3563, 5007, 5009
37, 1279, 1184, 677, 697, 4962, 5011, 5010, 
4963, 4964, 5012
38, 850, 1269, 1273, 1271, 5013, 5017, 5015, 
5014, 5016, 5018
39, 1124, 1196, 1323, 1329, 5019, 5023, 5021, 
5020, 5022, 5024
40, 409, 408, 281, 915, 1786, 5026, 5025, 
3886, 3885, 5027
41, 625, 1309, 1307, 1186, 5028, 5032, 5030, 
5029, 5031, 5033
42, 1102, 1320, 1295, 1109, 5034, 5037, 5035, 
4748, 5036, 5038
43, 436, 1313, 437, 1086, 5000, 5002, 1827, 
4644, 5039, 4645
44, 330, 35, 995, 1243, 1665, 4281, 4280, 
5040, 5041, 5042
45, 688, 93, 1203, 637, 2842, 5045, 5044, 
5043, 2452, 5046
46, 652, 1241, 1166, 1233, 5047, 5051, 5049, 
5048, 5050, 5052
47, 16, 431, 524, 523, 1820, 5054, 2035, 
2034, 5053, 2222
48, 700, 93, 574, 1191, 5055, 2148, 5057, 
5056, 5058, 5059
49, 717, 1182, 1277, 1183, 5060, 5063, 5061, 
5009, 5062, 5064
50, 805, 566, 868, 1357, 4914, 5067, 3640, 
5065, 5066, 5068
51, 827, 702, 472, 260, 3287, 5070, 5069, 
3241, 2953, 5071
52, 523, 522, 1051, 1183, 2221, 5075, 5073, 
5072, 5074, 5076
53, 1069, 185, 526, 186, 4578, 2039, 5077, 
4580, 1496, 2040
54, 1286, 1287, 1282, 1075, 5078, 5082, 5080, 
5079, 5081, 5083
55, 93, 1191, 1203, 635, 5058, 5085, 5045, 
2494, 5084, 5086
56, 1313, 628, 1315, 1316, 5087, 5090, 5088, 
5001, 5089, 5091
57, 1363, 211, 1152, 212, 5092, 2713, 5094, 
5093, 1528, 2711
58, 643, 617, 1296, 629, 2482, 5096, 5095, 
2481, 2480, 5097
59, 861, 1199, 869, 704, 5098, 5100, 3543, 
3550, 5099, 3560
60, 89, 573, 680, 1321, 2146, 5103, 2816, 
5101, 5102, 5104
61, 871, 771, 1286, 822, 3565, 5106, 5105, 
3658, 3669, 5107
62, 1335, 632, 1198, 1340, 5108, 5112, 5110, 
5109, 5111, 5113
63, 1148, 803, 1356, 1355, 5114, 5118, 5116, 
5115, 5117, 5119
64, 1356, 1148, 1147, 373, 5116, 3702, 5121, 
5120, 3701, 3703
65, 1357, 566, 868, 490, 5066, 5067, 5068, 
5122, 2541, 5123
66, 1347, 1130, 1141, 443, 5124, 4871, 5126, 
5125, 4857, 4867
67, 374, 1149, 1355, 1148, 3711, 5128, 5127, 
3713, 3712, 5115
68, 1259, 233, 695, 671, 5129, 2931, 5131, 
5130, 2739, 5132
69, 964, 929, 965, 963, 5133, 5135, 4094, 
4141, 5134, 4123
70, 1266, 819, 693, 881, 4904, 3388, 5136, 
4955, 3653, 3621
71, 481, 1277, 619, 480, 5137, 5139, 2651, 
2175, 5138, 2664
72, 1186, 294, 1308, 1187, 5140, 5144, 5142, 
5141, 5143, 5145
73, 1076, 1065, 1285, 1073, 4603, 5147, 5146, 
4608, 4601, 5148
74, 618, 519, 520, 1181, 2408, 2218, 2409, 
5149, 5150, 5151
75, 82, 1289, 674, 83, 5152, 5154, 2805, 
1378, 5153, 2804
76, 1356, 1148, 217, 1147, 5116, 3909, 5155, 
5121, 3702, 3910
77, 1270, 1269, 1271, 1178, 5156, 5016, 4903, 
5157, 5158, 5159
78, 1146, 1353, 1144, 1140, 5160, 5162, 4135, 
4712, 5161, 4713
79, 1148, 564, 1355, 1356, 5163, 5165, 5115, 
5116, 5164, 5119
80, 1148, 803, 373, 1356, 5114, 3165, 3701, 
5116, 5118, 5120
81, 1003, 991, 1235, 1237, 4323, 5169, 5167, 
5166, 5168, 4921
82, 266, 1362, 113, 829, 5170, 5172, 2885, 
3246, 5171, 5173
83, 1148, 803, 374, 373, 5114, 3166, 3713, 
3701, 3165, 1718
84, 1186, 294, 720, 1308, 5140, 2993, 5174, 
5142, 5144, 5175
85, 1124, 1127, 1329, 1323, 4807, 5177, 5020, 
5021, 5176, 5024
86, 472, 827, 473, 708, 5069, 5179, 1926, 
5178, 3440, 5180
87, 1067, 1271, 775, 39, 4875, 4877, 4879, 
4565, 4894, 3106
88, 956, 940, 968, 949, 5181, 5183, 4100, 
4064, 5182, 4102
89, 1051, 431, 183, 523, 4501, 4477, 4502, 
5073, 5053, 2033
90, 1357, 1150, 1149, 375, 5184, 3705, 5186, 
5185, 3704, 3706
91, 1267, 1265, 1268, 1266, 5187, 5190, 5188, 
4949, 5189, 5191
92, 59, 57, 962, 961, 1751, 4083, 5193, 
5192, 4074, 4106
93, 1257, 1015, 424, 1014, 5194, 4358, 5196, 
5195, 4361, 4356
94, 1299, 1278, 579, 1279, 5197, 5201, 5199, 
5198, 5200, 5202
95, 859, 867, 1299, 1296, 3562, 5206, 5204, 
5203, 5205, 5207
96, 1201, 584, 462, 2, 5208, 2497, 5210, 
5209, 2496, 1880
97, 1177, 673, 456, 1185, 5211, 5215, 5213, 
5212, 5214, 5216
98, 1296, 867, 853, 859, 5205, 3651, 5217, 
5203, 3562, 3581
99, 1257, 1014, 1173, 1015, 5195, 5219, 5218, 
5194, 4361, 5220
100, 1333, 132, 1308, 932, 5221, 5224, 5223, 
5222, 3966, 5225
101, 1201, 2, 462, 689, 5209, 1880, 5210, 
5226, 2916, 5227
102, 1313, 1093, 1085, 1310, 5228, 4669, 5230, 
5229, 5231, 5232
103, 948, 932, 955, 939, 5233, 5235, 4076, 
5234, 4013, 5236
104, 961, 943, 962, 59, 4130, 4119, 4106, 
5192, 5237, 5193
105, 1315, 245, 825, 683, 5238, 3224, 5240, 
5239, 2771, 5241
106, 1313, 628, 627, 1315, 5087, 2590, 5242, 
5088, 5090, 5243
107, 628, 1313, 627, 535, 5087, 5242, 2590, 
2430, 5244, 2429
108, 1117, 364, 1118, 1339, 4775, 4777, 4779, 
5245, 4958, 5246
109, 133, 292, 293, 930, 5247, 1621, 5248, 
3981, 5249, 5250
110, 640, 1315, 628, 1316, 5251, 5090, 2593, 
5252, 5091, 5089
111, 482, 1172, 612, 1252, 5253, 5256, 2455, 
5254, 5255, 5257
112, 708, 485, 282, 599, 4981, 5258, 2970, 
4983, 2364, 5259
113, 669, 230, 1263, 668, 2732, 5261, 5260, 
2734, 2730, 5262
114, 717, 1188, 292, 718, 5263, 5265, 2988, 
3273, 5264, 2989
115, 534, 1307, 1311, 626, 5266, 5269, 5267, 
2427, 5268, 5270
116, 534, 1307, 1088, 1311, 5266, 5272, 5271, 
5267, 5269, 5273
117, 535, 1313, 437, 628, 5244, 5002, 5274, 
2430, 5087, 5275
118, 465, 104, 275, 103, 1891, 2899, 5276, 
1890, 1400, 2900
119, 1186, 626, 1189, 1311, 5277, 5280, 5279, 
5278, 5270, 5281
120, 534, 1189, 626, 1311, 5282, 5280, 2427, 
5267, 5281, 5270
121, 640, 1315, 582, 628, 5251, 5283, 2680, 
2593, 5090, 2592
122, 679, 459, 1190, 1322, 5284, 5288, 5286, 
5285, 5287, 5289
123, 647, 1338, 660, 477, 5290, 5292, 2638, 
2524, 5291, 2637
124, 78, 669, 670, 453, 2794, 2737, 2797, 
1859, 5293, 5294
125, 814, 445, 1204, 560, 5295, 5299, 5297, 
5296, 5298, 5300
126, 1158, 283, 844, 1160, 5301, 3451, 5303, 
5302, 5304, 5305
127, 436, 1313, 1086, 1085, 5000, 5039, 4644, 
4642, 5230, 4647
128, 1156, 495, 1216, 1213, 5306, 5310, 5308, 
5307, 5309, 5311
129, 1321, 1096, 1111, 1108, 5312, 4750, 5314, 
5313, 4733, 4751
130, 268, 559, 814, 560, 5315, 5317, 3250, 
5316, 2262, 5296
131, 1257, 1014, 424, 1256, 5195, 4356, 5196, 
5318, 5319, 5320
132, 541, 1295, 1322, 1103, 5321, 5325, 5323, 
5322, 5324, 5326
133, 375, 1150, 805, 1357, 3704, 4912, 3169, 
5185, 5184, 5065
134, 725, 705, 597, 726, 3253, 5328, 5327, 
3277, 3422, 5329
135, 265, 466, 1363, 829, 5330, 5333, 5331, 
3247, 5332, 5334
136, 1090, 776, 1297, 432, 5335, 5338, 5336, 
4623, 5337, 5339
137, 126, 702, 125, 259, 5340, 5341, 1424, 
2875, 2954, 2877
138, 805, 1150, 376, 1358, 4912, 3721, 3170, 
4910, 4909, 4918
139, 1275, 1274, 638, 1174, 4930, 4927, 4926, 
5342, 5343, 5344
140, 1156, 495, 604, 1216, 5306, 2379, 5345, 
5308, 5310, 5346
141, 1296, 1300, 629, 1295, 5347, 5350, 5097, 
5348, 5349, 5351
142, 837, 1174, 1260, 1176, 5352, 5356, 5354, 
5353, 5355, 5357
143, 1257, 1256, 1173, 1014, 5318, 5358, 5218, 
5195, 5319, 5219
144, 1296, 629, 1301, 1295, 5097, 5360, 5359, 
5348, 5351, 5361
145, 1149, 804, 1355, 1357, 5362, 5364, 5128, 
5186, 5363, 5365
146, 408, 409, 281, 29, 1786, 5025, 5026, 
5366, 5367, 1608
147, 1150, 1358, 220, 446, 4909, 5368, 3848, 
3720, 4919, 3847
148, 50, 384, 63, 898, 1733, 3864, 1757, 
3773, 3775, 5369
149, 361, 43, 788, 1125, 1702, 3133, 3132, 
4800, 4765, 5370
150, 441, 1120, 1119, 1341, 4784, 4786, 4782, 
4998, 5371, 5372
151, 1150, 1357, 566, 805, 5184, 5066, 4913, 
4912, 5065, 4914
152, 141, 302, 303, 274, 4146, 1632, 4148, 
5373, 3011, 2961
153, 61, 60, 62, 959, 3845, 1756, 1754, 
4065, 5374, 5375
154, 439, 1351, 1137, 1325, 5376, 5379, 4570, 
5377, 5378, 5380
155, 1327, 799, 1352, 1137, 5381, 5385, 5383, 
5382, 5384, 5386
156, 1257, 1258, 1176, 1256, 5387, 5390, 5388, 
5318, 5389, 5391
157, 1150, 1357, 219, 566, 5184, 5392, 3873, 
4913, 5066, 2124
158, 838, 247, 688, 1350, 3410, 2844, 5394, 
5393, 5395, 5396
159, 1143, 1348, 1346, 1133, 5397, 5400, 5398, 
4575, 5399, 5401
160, 1180, 1181, 766, 715, 4978, 5405, 5403, 
5402, 5404, 3623
161, 1149, 565, 1357, 1355, 5406, 5408, 5186, 
5128, 5407, 5365
162, 31, 148, 310, 733, 4162, 4164, 1641, 
3022, 5409, 3023
163, 1148, 218, 1149, 1355, 3876, 3875, 3712, 
5115, 5410, 5128
164, 1334, 1127, 1122, 1129, 5411, 4824, 5413, 
5412, 4829, 4826
165, 1320, 1101, 1319, 1111, 5414, 5417, 5416, 
5415, 4745, 5418
166, 478, 1333, 649, 589, 5419, 5421, 2533, 
2358, 5420, 2532
167, 1198, 647, 631, 1195, 5422, 2599, 5424, 
5423, 5425, 5426
168, 1314, 582, 1324, 1315, 5427, 5430, 5429, 
5428, 5283, 5431
169, 1193, 875, 1332, 1192, 5432, 5436, 5434, 
5433, 5435, 5437
170, 1307, 192, 1088, 1078, 5438, 4652, 5272, 
5439, 4619, 4659
171, 1147, 467, 701, 1354, 5440, 5444, 5442, 
5441, 5443, 5445
172, 1333, 132, 478, 1308, 5221, 1936, 5419, 
5223, 5224, 5446
173, 1216, 1213, 495, 971, 5311, 5309, 5310, 
5447, 5448, 5449
174, 467, 802, 1147, 701, 5450, 5451, 5440, 
5444, 3365, 5442
175, 1349, 841, 838, 798, 5452, 3437, 5454, 
5453, 3436, 3435
176, 790, 1332, 722, 1331, 5455, 5458, 3634, 
5456, 5457, 5459
177, 1354, 22, 209, 444, 5460, 1525, 5462, 
5461, 1838, 4006
178, 1363, 1151, 379, 1152, 5463, 1899, 5464, 
5094, 1898, 1897
179, 808, 447, 1361, 1359, 5465, 5469, 5467, 
5466, 5468, 5470
180, 1069, 186, 526, 1283, 4580, 2040, 5077, 
5471, 5472, 5473
181, 1328, 1308, 639, 1189, 5474, 5478, 5476, 
5475, 5477, 5479
182, 1198, 1335, 1340, 1126, 5110, 5109, 5113, 
5480, 5481, 5482
183, 1278, 431, 523, 1281, 5483, 5053, 5485, 
5484, 5486, 5487
184, 969, 941, 967, 968, 5488, 5490, 4133, 
4111, 5489, 4142
185, 413, 412, 919, 897, 1791, 3899, 3898, 
4946, 5491, 4945
186, 273, 142, 304, 303, 5492, 4150, 3012, 
2962, 4147, 1633
187, 160, 1216, 971, 980, 5493, 5447, 4188, 
4221, 5494, 4222
188, 414, 415, 1206, 1210, 1798, 5498, 5496, 
5495, 5497, 5499
189, 152, 276, 105, 832, 5500, 2901, 1893, 
5501, 3263, 5502
190, 1328, 1314, 656, 1205, 5503, 5507, 5505, 
5504, 5506, 5508
191, 548, 1342, 634, 547, 5509, 5511, 2443, 
2246, 5510, 2442
192, 1335, 632, 631, 1198, 5108, 2598, 5512, 
5110, 5112, 5424
193, 1276, 1180, 715, 1181, 5513, 5402, 5515, 
5514, 4978, 5404
