*Heading
Kurbel, lineare Tetraeder, grobes Netz
*Node
1, 20, 300, -148.6607
2, 20, 360, -148.6607
3, 92.358482, 360, -117.2324
4, 143.33634, 360, -41.925887
5, 138.31134, 360, 55.305715
6, 91.731073, 360, 117.79672
7, 20, 360, 148.6607
8, -20, 300, -148.6607
9, -20, 360, -148.6607
10, -91.266145, 360, -118.21489
11, -140.03512, 360, -50.715894
12, -142.71279, 360, 43.586205
13, -88.724252, 360, 120.50119
14, -20, 360, 148.6607
15, 20, 300, -93.89356
16, -20, 300, -93.89356
17, -20, 300, 148.6607
18, 20, 300, 148.6607
19, -20, 300, 93.89356
20, 20, 300, 93.89356
21, 20, 360, 93.89356
22, 20, 360, -93.89356
23, -20, 360, 93.89356
24, -74.866156, 360, 58.682507
25, -95.217951, 360, -5.7109261
26, -69.084239, 360, -65.82573
27, -20, 360, -93.89356
28, 71.041083, 360, 63.408162
29, 95.841413, 360, 1.1580852
30, 72.752122, 360, -61.294274
31, 480.1787, 0, -79.57472
32, 452.13899, 0, -17.616045
33, 460.96067, 0, 48.424311
34, 507.06705, 0, 101.50551
35, 571.34026, 0, 119.1251
36, 635.30647, 0, 100.2598
37, 678.61681, 0, 49.538403
38, 687.79574, 0, -18.153584
39, 660.2469, 0, -78.958131
40, 603.67482, 0, -114.3901
41, 537.05264, 0, -114.56941
42, 258.5671, 0, -247.9106
43, 377.48106, 0, -225.46844
44, 506.60134, 0, -203.72946
45, 600.28815, 0, -190.0411
46, 695.85464, 0, -178.74399
47, 802.41795, 0, -167.66123
48, 884.67202, 0, -161.75826
49, 961.63615, 0, -156.96664
50, 1038.6488, 0, -153.34461
51, 1106.1841, 0, -151.94468
52, 1195.4787, 0, -150.09372
53, 1266.3078, 0, -134.37567
54, 1315.1138, 0, -95.684581
55, 1346.2671, 0, -33.128863
56, 1346.1326, 0, 33.682338
57, 1317.8225, 0, 92.652105
58, 1272.2102, 0, 130.66682
59, 1208.2945, 0, 149.06544
60, 1129.6044, 0, 151.45921
61, 1053.7734, 0, 153.03109
62, 960.81306, 0, 157.01788
63, 883.84893, 0, 161.8095
64, 803.03953, 0, 167.59659
65, 697.67545, 0, 178.55462
66, 600.66515, 0, 189.98602
67, 506.97835, 0, 203.67438
68, 386.93064, 0, 223.68506
69, 258.47725, 0, 247.93145
70, 170.49539, 0, 268.34483
71, 110.06778, 0, 282.36513
72, 64.864225, 0, 292.33782
73, 24.134217, 0, 298.69251
74, -11.508876, 0, 299.45082
75, -51.639739, 0, 294.9281
76, -97.903915, 0, 283.07542
77, -148.05641, 0, 260.74514
78, -181.60501, 0, 238.51352
79, -210.51285, 0, 212.91478
80, -235.45363, 0, 184.5873
81, -260.27028, 0, 147.52391
82, -283.34665, 0, 97.029855
83, -295.81429, 0, 48.52736
84, -299.14166, 0, 11.300243
85, -298.15815, 0, -24.248493
86, -293.28286, 0, -59.464879
87, -281.47006, 0, -101.74103
88, -260.72164, 0, -146.75479
89, -235.69148, 0, -184.29456
90, -209.43141, 0, -213.89601
91, -180.46871, 0, -239.26652
92, -136.18014, 0, -266.59433
93, -90.859462, 0, -285.1162
94, -50.179042, 0, -295.1196
95, -14.817673, 0, -299.52121
96, 20.8254, 0, -298.76291
97, 60.210435, 0, -293.15056
98, 111.2229, 0, -282.09712
99, 172.7687, 0, -267.81738
100, -182.4335, 0, 182.4335
101, -163.89504, 0, 190.68826
102, -144.54217, 0, 185.46374
103, -132.81647, 0, 169.2445
104, -133.94669, 0, 149.07726
105, -148.70031, 0, 134.19855
106, -168.79984, 0, 132.72802
107, -185.21187, 0, 144.16521
108, -190.77671, 0, 163.45037
109, 836.3604, 0, 63.63961
110, 884.19858, 0, 87.919699
111, 930.10913, 0, 84.11028
112, 968.63281, 0, 57.13234
113, 988.1004, 0, 14.428785
114, 984.5195, 0, -29.121167
115, 959.83335, 0, -66.560252
116, 922.99118, 0, -86.973148
117, 877.49099, 0, -87.036627
118, 837.4813, 0, -64.499706
119, 813.69833, 0, -24.818612
120, 812.57749, 0, 19.577827
121, -27.02907, 0, 241.0165
122, -14.082543, 0, 253.68081
123, 4.2293332, 0, 257.2478
124, 20.520837, 0, 249.17753
125, 28.745176, 0, 233.49775
126, 26.978642, 0, 214.92027
127, 13.792165, 0, 202.17935
128, -4.1360252, 0, 198.7522
129, -20.229919, 0, 206.45767
130, -28.641349, 0, 222.04736
131, -251.4549, 0, 18.70469
132, -236.28299, 0, 28.109462
133, -218.71497, 0, 27.880753
134, -204.01817, 0, 17.610513
135, -198.7522, 0, -0.51389923
136, -204.30215, 0, -18.20021
137, -218.80719, 0, -27.901802
138, -237.64896, 0, -27.797688
139, -252.62968, 0, -16.26523
140, -257.2478, 0, 0.70054379
141, 1097.574, 0, 42.42641
142, 1134.3091, 0, 59.250772
143, 1185.9497, 0, 60
144, 1224.1723, 0, 54.375415
145, 1251.9302, 0, 30.041378
146, 1259.8182, 0, -1.3812661
147, 1250.1939, 0, -32.304051
148, 1223.8163, 0, -54.522871
149, 1186.5742, 0, -60
150, 1139.7295, 0, -59.964394
151, 1104.0912, 0, -47.427358
152, 1084.1399, 0, -20.589132
153, 1081.8237, 0, 13.855659
154, -83.13844, 0, 48
155, -38.513508, 0, 87.067874
156, 8.4828827, 0, 94.883208
157, 52.041274, 0, 80.037461
158, 84.735007, 0, 44.145545
159, 93.64135, 0, -17.915727
160, 61.057052, 0, -73.11941
161, 5.5732081, 0, -95.266273
162, -39.708666, 0, -86.572823
163, -76.577402, 0, -56.55051
164, -95.339411, 0, -5.0176748
165, -182.4335, 0, -140.0071
166, -163.99384, 0, -131.77201
167, -144.70971, 0, -136.86496
168, -132.87544, 0, -152.89967
169, -133.72279, 0, -173.02824
170, -147.71595, 0, -187.5844
171, -167.76226, 0, -189.91903
172, -185.07192, 0, -178.48484
173, -190.66861, 0, -158.44673
174, -27.02907, 0, -214.9835
175, -14.628544, 0, -202.58213
176, 3.3059375, 0, -198.7522
177, 19.832867, 0, -205.95978
178, 28.666479, 0, -222.15746
179, 27.314339, 0, -239.76665
180, 14.024982, 0, -253.70853
181, -3.0947689, 0, -257.2478
182, -19.920475, 0, -249.93036
183, -28.744086, 0, -233.50252
184, -61.41276, 60, 293.6469
185, -109.03636, 60, 279.16165
186, -157.33903, 60, 254.59384
187, -188.58731, 60, 232.80876
188, -217.44751, 60, 206.62266
189, -241.56261, 60, 177.06852
190, -267.81995, 60, 134.65906
191, -288.00263, 60, 82.279183
192, -297.20239, 60, 36.83127
193, -299.92571, 60, 0.97810078
194, -297.35098, 60, -34.875068
195, -290.5773, 60, -71.154813
196, -275.32682, 60, -117.16361
197, -252.77162, 60, -160.30186
198, -227.74404, 60, -194.07606
199, -199.32297, 60, -223.06784
200, -167.75054, 60, -247.69445
201, -121.03345, 60, -273.60711
202, -74.549899, 60, -289.84108
203, -36.887794, 60, -296.86203
204, -1.110491, 60, -299.22959
205, 34.753253, 60, -297.59645
206, 78.445071, 60, -289.70217
207, 135.78104, 60, -276.39919
208, 202.73, 60, -260.86582
209, 285.10014, 60, -242.90312
210, 394.4389, 60, -222.26806
211, 516.05575, 60, -202.3481
212, 610.54487, 60, -188.54252
213, 709.45103, 60, -177.32994
214, 814.78841, 60, -166.37468
215, 895.07528, 60, -161.11057
216, 972.74397, 60, -156.27509
217, 1049.7624, 60, -153.11424
218, 1118.7672, 60, -151.68385
219, 1211.8425, 60, -148.66567
220, 1275.2611, 60, -128.74975
221, 1322.6551, 60, -84.960796
222, 1347.8006, 60, -19.519143
223, 1343.5808, 60, 40.974772
224, 1313.123, 60, 97.675352
225, 1265.9561, 60, 134.59669
226, 1206.5001, 60, 149.26761
227, 1130.9317, 60, 151.4317
228, 1052.4707, 60, 153.0581
229, 958.8652, 60, 157.13915
230, 881.24197, 60, 161.97181
231, 798.89316, 60, 168.02781
232, 691.80115, 60, 179.16556
233, 595.08479, 60, 190.80135
234, 500.59567, 60, 204.60694
235, 378.97782, 60, 225.18597
236, 242.80846, 60, 251.56689
237, 158.65484, 60, 271.09205
238, 101.92095, 60, 284.25534
239, 56.324092, 60, 293.82928
240, 17.142327, 60, 298.84126
241, -18.785757, 60, 299.23513
242, 676.2547, 60, 55.76678
243, 629.40822, 60, 103.35542
244, 564.67901, 60, 119.1251
245, 501.2714, 60, 98.261235
246, 458.59855, 60, 42.195934
247, 452.94192, 60, -24.228725
248, 485.16472, 60, -83.991948
249, 543.52032, 60, -116.16357
250, 610.1425, 60, -112.79594
251, 664.03092, 60, -73.476026
252, 688.59867, 60, -11.540904
253, -172.7008, 60, 188.9367
254, -187.42157, 60, 174.96835
255, -189.91233, 60, 154.64463
256, -179.12644, 60, 137.79742
257, -159.99411, 60, 131.46421
258, -141.23514, 60, 139.18656
259, -131.90782, 60, 157.76402
260, -136.53418, 60, 177.23585
261, -152.41453, 60, 189.46873
262, 855, 60, 77.94229
263, 820.72437, 60, 41.781047
264, 810.79387, 60, -6.0300175
265, 823.02535, 60, -46.261059
266, 856.41215, 60, -78.52722
267, 904.09107, 60, -89.4614
268, 944.6617, 60, -78.082417
269, 976.80021, 60, -46.4884
270, 989.16872, 60, -6.314129
271, 979.51172, 60, 41.211066
272, 947.87999, 60, 75.732391
273, 907.37435, 60, 89.029146
274, -18.70469, 60, 251.4549
275, -28.304659, 60, 235.42778
276, -27.428876, 60, 216.73516
277, -15.743945, 60, 203.11928
278, 1.5964273, 60, 198.7522
279, 18.879241, 60, 204.76398
280, 28.159298, 60, 219.93535
281, 27.518865, 60, 238.87057
282, 16.164332, 60, 252.67827
283, -1.503119, 60, 257.2478
284, -241.0165, 60, 27.02907
285, -253.48053, 60, 14.498429
286, -257.2478, 60, -4.1546978
287, -249.77581, 60, -20.043728
288, -232.91545, 60, -28.87808
289, -214.4776, 60, -26.625626
290, -202.19554, 60, -13.825789
291, -198.7522, 60, 4.3413438
292, -207.39158, 60, 20.974695
293, -223.44848, 60, 28.961145
294, 1110, 60, 51.96152
295, 1086.8864, 60, 27.219884
296, 1080.7955, 60, -6.0438991
297, 1093.4368, 60, -37.035246
298, 1123.1696, 60, -57.41648
299, 1166.6832, 60, -60
300, 1208.8424, 60, -58.835869
301, 1240.7464, 60, -43.71526
302, 1258.1511, 60, -14.047119
303, 1257.127, 60, 17.530589
304, 1238.1454, 60, 45.711141
305, 1202.4662, 60, 59.675309
306, 1157.5238, 60, 60
307, -93.52347, 60, 117.2747
308, -123.76124, 60, 83.200192
309, -144.50431, 60, 38.336159
310, -149.63875, 60, 3.2062235
311, -146.37358, 60, -32.185447
312, -134.09441, 60, -66.75505
313, -106.17264, 60, -104.62553
314, -69.803754, 60, -132.17878
315, -25.279103, 60, -147.15174
316, 10.112572, 60, -148.86059
317, 45.746754, 60, -141.91122
318, 95.647129, 60, -115.15104
319, 141.55861, 60, -46.75444
320, 144.78204, 60, 37.542436
321, 101.52358, 60, 109.27459
322, 57.335908, 60, 137.85598
323, 18.831764, 60, 147.87818
324, -14.449587, 60, 148.37193
325, -59.207677, 60, 137.20102
326, -172.7008, 60, -133.504
327, -187.36561, 60, -147.38851
328, -190.04008, 60, -167.1537
329, -179.00075, 60, -184.7272
330, -159.05531, 60, -190.78966
331, -140.33455, 60, -182.65229
332, -131.84885, 60, -164.3801
333, -136.64614, 60, -145.0372
334, -152.51338, 60, -132.95228
335, -18.70469, 60, -204.5451
336, -27.994263, 60, -219.21229
337, -27.737362, 60, -237.91327
338, -16.782917, 60, -252.38038
339, 1.4294145, 60, -257.2478
340, 18.054149, 60, -251.76818
341, 28.321063, 60, -235.35591
342, 27.659754, 60, -217.74671
343, 16.65632, 60, -203.55866
344, -1.2182449, 60, -198.7522
345, 396.16027, 0, -64.140614
346, 378.20872, 0, 36.194775
347, 428.75678, 0, 123.2709
348, 439.87167, 0, -140.12498
349, 721.35267, 0, 99.375764
350, 730.04357, 0, 23.004728
351, 736.47401, 0, -76.274706
352, 310.03412, 0, -135.49194
353, 1002.6018, 0, -89.088999
354, 1266.6359, 0, 70.077563
355, 198.06733, 0, 185.51026
356, 79.523336, 0, 251.65457
357, -69.276296, 0, 255.27384
358, -144.45032, 0, 212.95481
359, -232.48024, 0, 114.28056
360, -265.44181, 0, -34.59736
361, -230.78182, 0, -107.93351
362, -107.27886, 0, -232.33702
363, 33.840968, 0, -267.88743
364, 124.66642, 0, -222.25503
365, -122.2579, 0, 189.29738
366, -110.30616, 0, 158.78665
367, -122.25384, 0, 118.56141
368, -160.66207, 0, 111.01577
369, -191.23018, 0, 122.90941
370, -214.0996, 0, 147.11372
371, 1017.4242, 0, 48.999731
372, 1024.1517, 0, -0.45693721
373, 780.86407, 0, 69.607212
374, 791.62332, 0, -55.730463
375, 774.98102, 0, -6.8168801
376, -33.636699, 0, 265.14996
377, -3.8825596, 0, 275.05279
378, 18.406709, 0, 269.7438
379, 44.246699, 0, 259.89311
380, 53.094252, 0, 229.21657
381, -47.68085, 0, 235.98692
382, 32.932622, 0, 191.37091
383, 9.9482311, 0, 180.02516
384, -29.779446, 0, 186.90611
385, -44.5654, 0, 209.20621
386, -255.20689, 0, 41.216978
387, -228.50248, 0, 46.658643
388, -204.64724, 0, 41.520444
389, -184.26996, 0, 14.639025
390, -183.84096, 0, -14.707251
391, -271.92044, 0, 18.290015
392, -202.75953, 0, -43.497315
393, -223.82817, 0, -48.846066
394, -274.50471, 0, -8.6371676
395, 1075.2103, 0, 84.62597
396, 1295.8308, 0, 24.988323
397, 1292.9416, 0, -24.962439
398, 1057.3123, 0, 32.475408
399, 1051.8651, 0, -51.232671
400, 1057.5282, 0, -5.904982
401, -16.736232, 0, 129.16832
402, 40.034622, 0, 126.99827
403, 101.24059, 0, 93.248479
404, 153.22242, 0, 23.986748
405, -133.15497, 0, 19.71079
406, 131.94027, 0, -85.980544
407, 57.066765, 0, -124.61462
408, -22.506745, 0, -123.7109
409, -90.226554, 0, -99.484716
410, -133.83523, 0, -48.298725
411, -185.2619, 0, -114.79428
412, -151.4938, 0, -115.30565
413, -120.70212, 0, -130.9545
414, -111.78547, 0, -164.45604
415, -211.90824, 0, -142.37547
416, -125.47144, 0, -193.75173
417, -147.87924, 0, -216.29684
418, -31.259469, 0, -193.75529
419, -11.929928, 0, -184.66571
420, 19.058783, 0, -186.08721
421, 38.729805, 0, -209.84385
422, 46.028371, 0, -225.85659
423, -51.432814, 0, -222.11784
424, 6.1986129, 0, -276.1735
425, -19.448216, 0, -273.04375
426, -39.772023, 0, -260.3821
427, 998.73658, 0, 101.97222
428, 810.51009, 0, -100.72672
429, 187.36625, 0, -172.796
430, 1229.8035, 0, 93.888902
431, 835.53776, 0, 114.36099
432, 310.85989, 0, 144.46432
433, 126.91434, 0, 233.80179
434, -108.10384, 0, 229.65733
435, -244.75738, 0, 76.34449
436, -248.41764, 0, -64.111561
437, -70.159193, 0, -261.71008
438, 68.137546, 0, -243.32304
439, 54.860111, 0, 201.91798
440, -12.954555, 0, 168.72194
441, -175.04964, 0, 36.976977
442, 40.056024, 0, -188.24258
443, -53.49335, 0, -200.81574
444, 217.62483, 0, -57.411391
445, 126.38579, 0, 182.46475
446, -93.583244, 0, 191.01142
447, -177.47616, 0, -0.1957217
448, 4.3290565, 0, -175.92809
449, -51.931827, 0, -242.19978
450, 246.7498, 0, 65.291567
451, 87.391774, 0, 216.85064
452, -196.04161, 0, 93.201483
453, 113.9227, 0, -164.97456
454, -71.905516, 0, 219.7445
455, -206.53564, 0, -76.502141
456, -158.67427, 0, -13.085834
457, 24.088927, 0, -158.11591
458, -163.76007, 0, 12.906098
459, -60.810599, 0, 189.18004
460, 31.139568, 0, 163.40618
461, -212.3448, 0, 65.057627
462, 94.394093, 0, 143.52895
463, 156.9273, 0, 118.32148
464, -130.40257, 0, -94.763744
465, -84.353049, 0, -137.44821
466, -101.23374, 0, -193.71453
467, -164.62532, 0, -87.869371
468, -29.417656, 0, -172.52227
469, 61.568393, 0, -208.00633
470, 57.669743, 0, 168.02952
471, -78.703885, 0, -175.51628
472, -186.14685, 0, 62.949672
473, -178.0993, 0, -33.93543
474, -73.881508, 0, -233.71503
475, -148.91517, 0, 75.473755
476, -73.918063, 0, 132.7868
477, -78.463246, 0, -208.91749
478, 7.305487, 0, 152.09746
479, 310.98939, 0, -31.790732
480, -44.388235, 0, 160.39089
481, 90.34529, 0, -203.99147
482, -11.440626, 0, -157.3999
483, -50.40062, 0, -179.89449
484, -177.89382, 0, -60.069378
485, 68.044284, 0, -173.88113
486, -78.018438, 0, 165.87497
487, -47.86974, 0, -151.56518
488, 85.706541, 0, 183.57341
489, -165.60463, 28.961152, 249.11648
490, -222.20694, 28.056417, 200.89098
491, -297.09885, 31.397988, -38.19441
492, -205.32425, 29.052388, -217.62261
493, -7.9366693, 30.116216, -299.37482
494, -197.68748, 29.724883, 224.55179
495, -80.656772, 60, 247.362
496, -154.50721, 60, 213.91801
497, -230.27446, 60, 137.43297
498, -255.53717, 60, 65.100827
499, -273.42285, 60, -53.410619
500, -251.31024, 60, -89.828944
501, -213.89883, 60, -153.30118
502, -84.983704, 60, -248.71774
503, 56.614664, 60, -257.64969
504, 153.72486, 60, -210.74852
505, 236.78864, 60, -178.97756
506, 339.94125, 60, -152.07065
507, 736.15983, 60, -94.273706
508, 1089.9096, 60, -104.91112
509, 1294.5543, 60, 5.8377792
510, 1270.6059, 60, 67.672153
511, 290.52586, 60, 123.06854
512, 118.62635, 60, 229.9714
513, 33.825249, 60, 272.02603
514, 421.61972, 60, 120.06142
515, 390.20372, 60, 31.408035
516, 757.05476, 60, 30.210827
517, 389.45925, 60, -68.007197
518, 447.8377, 60, -143.02639
519, -211.43868, 60, 165.33329
520, -203.19355, 60, 140.48664
521, -170.84532, 60, 113.32352
522, -139.92704, 60, 113.66537
523, -115.50035, 60, 143.72258
524, -114.26996, 60, 178.17593
525, -134.17254, 60, 196.63784
526, 789.97314, 60, 87.453651
527, 769.74114, 60, -34.742251
528, 1017.3892, 60, -37.827617
529, 1021.3817, 60, 13.738052
530, 1017.8259, 60, 77.440002
531, -47.591199, 60, 253.25139
532, -53.765113, 60, 227.46194
533, -31.062787, 60, 194.87769
534, -12.848725, 60, 181.33428
535, 16.791759, 60, 181.29638
536, -12.140973, 60, 270.8043
537, 39.076721, 60, 204.59842
538, 40.684026, 60, 226.42146
539, 8.0272317, 60, 274.59643
540, -272.30024, 60, -22.879823
541, -253.31846, 60, -37.86896
542, -219.83424, 60, -44.843054
543, -233.74186, 60, 46.763086
544, -186.23229, 60, -32.222525
545, -177.8174, 60, -6.6691055
546, -180.70175, 60, 23.992699
547, 1076.4556, 60, 79.876341
548, 1054.6515, 60, 26.94986
549, 1056.721, 60, -25.755261
550, 1083.0579, 60, -61.668252
551, 1124.4101, 60, 87.841912
552, 1244.378, 60, -83.884858
553, 1283.5957, 60, -48.981448
554, -169.94897, 60, -62.922085
555, -59.20917, 60, -171.87039
556, 44.366016, 60, -169.69979
557, 97.859163, 60, -170.59394
558, 174.67766, 60, -121.31872
559, 219.03701, 60, 3.5318421
560, 178.48596, 60, 109.11282
561, 108.96221, 60, 173.18475
562, 56.030837, 60, 183.10125
563, -195.80954, 60, -122.69773
564, -161.78803, 60, -97.548841
565, -136.63689, 60, -202.14753
566, -120.31252, 60, -183.32705
567, -115.55854, 60, -137.61935
568, -143.0315, 60, -118.54208
569, -44.338429, 60, -200.93037
570, -44.882798, 60, -223.31205
571, 16.825288, 60, -273.39181
572, -18.551298, 60, -179.67573
573, 53.873491, 60, -229.43691
574, 32.228291, 60, -203.96206
575, 11.261919, 60, -179.09766
576, -47.524414, 60, -263.5011
577, 721.03009, 60, 105.96696
578, 1008.9301, 60, -97.790693
579, -118.37954, 60, 222.46825
580, -243.34938, 60, 101.17865
581, -232.0235, 60, -121.92021
582, -164.02525, 60, -211.88102
583, -130.20422, 60, -231.64571
584, 93.223249, 60, -237.41522
585, 1167.9747, 60, 102.37367
586, 72.673161, 60, 251.87885
587, 178.68933, 60, 195.18084
588, -201.98765, 60, 110.84453
589, 799.1419, 60, -86.840086
590, -256.30653, 60, 37.996423
591, -172.80091, 60, 77.002291
592, -87.303722, 60, 160.17313
593, -47.108044, 60, 172.93429
594, -49.796227, 60, 202.69175
595, -199.64098, 60, -53.731248
596, -54.186662, 60, -241.82076
597, -94.77055, 60, -201.69193
598, -32.017448, 60, 273.33868
599, -203.38784, 60, -90.763903
600, 314.74874, 60, -1.9086559
601, -235.67827, 60, -48.063029
602, -99.972388, 60, -166.30002
603, 28.145319, 60, -188.77149
604, 278.85842, 60, -85.241789
605, 59.643486, 60, 221.79277
606, 43.375246, 60, 246.34524
607, -206.86, 60, 44.970254
608, 46.946071, 60, -211.4568
609, 33.600971, 60, -261.26727
610, -82.666296, 60, 200.2523
611, 45.143283, 60, -193.66811
612, -224.52858, 60, -68.725637
613, -68.216052, 60, -220.97365
614, 1049.744, 60, -67.75383
615, -219.96673, 60, 73.937159
616, 85.410895, 60, 212.21624
617, -248.27031, 60, -62.533259
618, 69.233581, 60, -200.8399
619, 148.74407, 277.09911, 11.024311
620, -12.50315, 228.35033, -149.19695
621, -124.30738, 284.08738, -82.343295
622, -148.47264, 287.51531, 13.206204
623, -111.34652, 283.1211, 100.09113
624, 17.987901, 242.67867, 148.66907
625, -107.3663, 101.36854, 103.55044
626, -132.56285, 101.69779, 69.307298
627, -147.15592, 102.46075, 25.241973
628, -148.29675, 103.57831, -15.116828
629, -138.85881, 101.36704, -54.568844
630, -118.29429, 96.056119, -91.888676
631, -86.575509, 97.34487, -121.74953
632, -46.254415, 103.54595, -141.86314
633, -6.8985746, 98.424701, -149.36908
634, 35.907774, 97.13242, -145.45388
635, 83.836718, 105.68758, -123.49481
636, 149.3433, 134.53091, 5.8283595
637, 125.54012, 126.14695, 80.551233
638, 79.869751, 110.40529, 126.00121
639, 4.3481032, 94.272641, 149.64063
640, -33.282819, 93.685056, 146.12956
641, 118.37063, 277.29924, -91.070313
642, 105.33426, 272.74105, 105.87845
643, -75.064967, 98.748187, 128.98619
644, 129.15457, 125.12496, -74.79605
645, 39.393787, 92.138493, 144.22985
646, -80.734056, 233.59123, -125.81815
647, -47.904304, 242.259, 141.69853
648, 32.054884, 136.78398, 146.26821
649, -147.8485, 221.73344, -18.858884
650, 77.6639, 187.79535, 127.61341
651, -140.07427, 144.56046, 51.198468
652, -149.04537, 157.17342, 8.4725741
653, -144.46324, 155.3834, -38.681405
654, -127.22869, 144.97334, -77.91571
655, -101.12568, 132.91686, -109.88148
656, -63.877777, 159.37347, -135.4437
657, -19.800032, 152.04873, -148.11969
658, 19.571243, 133.96537, -148.07659
659, 59.980232, 144.1901, -137.18118
660, 61.403879, 239.51648, -136.49143
661, -48.520025, 131.3549, 141.15311
662, -93.831709, 205.12508, 116.4701
663, -83.895422, 148.07026, 123.58179
664, -119.56595, 151.41649, 89.809205
665, -11.345851, 128.0286, 148.98075
666, -138.50335, 211.23741, 55.462304
667, 139.94198, 203.7584, 51.665309
668, -22.772693, 182.65545, 147.90133
669, 100.61219, 184.07468, -110.4479
670, -128.81649, 210.19672, -75.568315
671, 35.57268, 187.74767, -145.17878
672, 144.91847, 202.08714, -37.492023
673, -103.51723, 180.49113, -107.62627
674, 0.34376135, 257.84142, -95.798188
675, -10.679178, 253.76603, 95.131949
676, -79.992785, 293.3257, -52.420352
677, -85.538219, 259.81792, 41.998008
678, 73.199552, 52.119638, 61.009619
679, 95.043449, 57.76247, 7.2657256
680, -90.51215, 49.545973, 30.243244
681, 78.136962, 58.181664, -54.581694
682, 29.905872, 52.553549, -90.702527
683, -20.823192, 47.499222, -93.361273
684, -67.690093, 46.164799, -68.046358
685, -92.966862, 46.520751, -22.98481
686, 79.645803, 302.5956, -52.868665
687, 78.790534, 291.21855, 53.943362
688, -58.39424, 51.798752, 75.225076
689, -14.82372, 40.740393, 94.136505
690, 29.965141, 47.712012, 90.671597
691, 40.585212, 252.90455, 86.543017
692, -48.325658, 247.00487, -82.520534
693, 75.003821, 219.52052, 58.735454
694, 52.693473, 247.89646, -79.41311
695, 15.792024, 205.53277, 94.334374
696, -86.201016, 229.91971, -40.518128
697, 94.566746, 251.01333, -10.756753
698, 86.907121, 110.3963, 39.001766
699, 51.107771, 94.248087, 80.781042
700, 0.99143509, 210.65436, -95.835121
701, -8.7895847, 94.369464, 95.046865
702, 45.221934, 113.25165, -84.438392
703, -9.4034914, 99.937594, -94.978082
704, -51.055402, 86.431541, -80.830508
705, -83.990956, 96.395251, -45.860642
706, 91.0233, 119.16902, -29.07239
707, 65.1227, 182.89974, -70.220124
708, 94.347636, 174.00779, 12.550952
709, -54.062896, 188.61012, -78.532015
710, -93.948136, 159.76438, -15.517298
711, -40.255245, 209.54687, 86.622558
712, -75.59387, 113.60162, 57.956537
713, -95.545746, 95.745869, 3.4504044
714, -4.8453865, 155.5699, -95.69845
715, 49.568829, 153.13572, 81.783308
716, -25.819286, 157.16429, 92.089254
717, -54.625347, 132.74551, -78.214592
718, -75.504616, 178.01368, 58.143312
719, -2.3246017, 21.299998, -198.7522
720, 14.717518, 16.048209, -202.62498
721, 27.60263, 15.190986, -217.49643
722, 28.610541, 15.027923, -234.08762
723, -28.761763, 18.06873, -222.57493
724, 20.536971, 14.579469, -249.1573
725, 3.0606368, 14.757156, -257.2478
726, -14.199338, 16.793129, -253.62457
727, -27.341921, 18.513425, -239.64581
728, -29.647141, 39.249954, -229.54598
729, -20.602935, 37.888747, -249.07459
730, -4.0058921, 43.762547, -257.2478
731, 13.747525, 44.37081, -253.84215
732, -13.277573, 39.8703, -201.93153
733, 27.396665, 44.873093, -239.40596
734, 28.812814, 45.280965, -222.7986
735, 21.417359, 45.667257, -207.94667
736, 4.4793041, 43.674661, -198.7522
737, -20.131361, 18.385752, -206.33408
738, -24.638873, 46.283025, -211.9863
739, 24.76759, 30.716263, -212.1477
740, 29.902106, 30.193866, -227.5711
741, 9.6067364, 29.487712, -255.83625
742, -7.1784702, 29.091397, -257.00564
743, -25.227574, 32.257481, -212.7245
744, 13.107164, 31.459802, -201.84947
745, 24.153892, 29.84575, -244.62184
746, -174.29363, 20.300124, -134.56828
747, -153.01888, 21.007126, -132.85173
748, -135.05912, 20.959063, -147.41236
749, -132.78439, 20.421113, -169.08321
750, -148.0927, 17.988181, -187.83614
751, -174.04918, 19.019101, -188.03574
752, -189.00981, 19.138137, -172.33323
753, -189.06566, 19.458226, -150.3881
754, -180.83072, 39.751343, -138.93617
755, -190.6119, 39.042633, -158.16166
756, -184.58737, 38.803622, -179.21001
757, -166.18591, 38.350718, -190.23258
758, -143.74336, 39.085977, -184.92999
759, -132.29536, 40.790287, -166.62481
760, -138.10169, 42.981179, -142.85878
761, -160.46712, 40.543366, -131.37012
762, -224.54639, 16.624471, 29.211737
763, -208.73802, 14.991208, 22.048445
764, -198.7522, 14.419325, 6.1543381
765, -200.95995, 16.189657, -11.260068
766, -255.5492, 14.496426, 10.202802
767, -211.58815, 19.536056, -24.321357
768, -231.24969, 20.006061, -29.258279
769, -249.30725, 20.576458, -20.417387
770, -257.2478, 13.193642, -6.1249678
771, -257.2478, 44.235942, 5.0784941
772, -254.04116, 41.712678, -13.334269
773, -240.20623, 40.284748, -27.214009
774, -221.34339, 39.58476, -28.480672
775, -233.10398, 48.471894, 28.835051
776, -203.76493, 37.658682, -17.084661
777, -198.7522, 43.853868, -0.18208961
778, -203.37829, 45.009068, 16.281786
779, -218.44425, 45.313188, 27.818964
780, -244.3735, 16.665288, 24.351938
781, -247.53767, 45.430407, 21.828586
782, -257.2478, 27.640856, -1.8784589
783, -201.72107, 29.601665, 12.840537
784, -198.7522, 28.197932, -2.2449991
785, -252.61737, 30.229088, 16.290803
786, -213.25613, 30.631411, 25.651535
787, -233.81381, 32.685657, 28.673037
788, -174.15806, 20.294362, 187.96299
789, -152.88731, 20.996207, 189.56277
790, -134.96494, 20.89953, 174.88728
791, -132.82909, 20.519691, 153.13266
792, -146.11149, 19.818725, 135.92833
793, -167.42767, 19.633916, 132.45507
794, -186.30861, 17.369069, 145.80659
795, -189.04053, 19.703122, 172.17883
796, -180.30596, 39.418656, 183.85508
797, -190.73761, 39.272583, 163.64698
798, -183.35314, 38.824795, 141.38344
799, -164.6791, 39.599074, 131.90832
800, -143.99124, 40.094124, 137.34502
801, -132.30779, 40.956021, 155.75331
802, -138.00721, 43.14344, 179.44041
803, -160.24816, 40.501754, 191.02693
804, -2.696589, 15.711107, 257.2478
805, 15.505358, 15.187346, 252.99562
806, 27.660849, 15.369125, 238.24849
807, 28.353121, 14.534235, 220.78455
808, -28.729765, 18.630276, 233.56526
809, 18.483848, 14.613923, 204.43875
810, 2.5738952, 14.544927, 198.7522
811, -14.708125, 15.575168, 202.62045
812, -27.238758, 18.090187, 215.9022
813, -29.228809, 38.789095, 224.62119
814, -21.047803, 37.502461, 207.48326
815, -3.3789982, 43.889514, 198.7522
816, 13.874803, 44.929813, 202.21915
817, -10.860497, 47.381824, 255.23247
818, 27.144519, 45.107253, 215.48932
819, 28.885843, 45.204705, 232.88144
820, 21.076759, 45.337479, 248.48043
821, 4.4721839, 45.778527, 257.2478
822, -20.266396, 17.078147, 249.49659
823, -23.730453, 39.69043, 245.15282
824, 24.561662, 30.368948, 244.11052
825, 29.629901, 30.344296, 226.37849
826, -8.6093099, 32.235829, 256.31659
827, 9.1605728, 29.673304, 199.94889
828, -7.2079003, 28.367019, 199.00853
829, 10.264159, 31.07188, 255.51965
830, 22.943346, 30.347667, 209.86019
831, 1237.1525, 29.012243, -46.473048
832, 1081.3182, 30.779222, -10.014898
833, 1259.0487, 30.276461, 7.2272669
834, 1248.5579, 31.502922, 34.43589
835, 1254.9115, 30.166154, -22.879265
836, 1086.9985, 28.516307, 27.49038
837, -91.347034, 28.230911, 207.2742
838, -102.50203, 29.654636, 168.5556
839, -52.718731, 29.939839, 159.11361
840, -82.239721, 31.824767, 122.16895
841, -18.995707, 21.951112, 157.20442
842, 7.0449239, 27.63458, 130.91
843, -39.454514, 26.525273, 127.32835
844, -123.69266, 30.39471, 105.03992
845, -166.08776, 30.414169, 104.82673
846, -144.0423, 29.768408, 56.384821
847, -177.53621, 24.032852, 65.003802
848, -159.53639, 32.638471, 18.252011
849, -211.06825, 31.14202, 104.56214
850, -227.27452, 35.061001, 42.086186
851, 75.000992, 29.871641, 236.81458
852, 63.837052, 28.07059, 204.06275
853, 21.295197, 24.475251, 158.78665
854, 93.426909, 31.033731, 196.7726
855, 92.068032, 32.547631, 148.86887
856, 57.744704, 26.307266, 169.35529
857, -266.16258, 27.78098, 48.738461
858, -147.53583, 31.3448, -15.171504
859, -240.3706, 18.656724, 43.595031
860, -221.843, 32.396462, -59.893556
861, -164.94854, 30.063905, -47.719075
862, -190.72332, 30.660621, -74.590028
863, -159.52788, 26.645054, -80.796231
864, -218.43645, 33.333375, -118.74213
865, -276.96317, 18.629648, -0.34073624
866, 1046.8981, 32.309944, -15.319813
867, 1010.8421, 27.661577, -24.00684
868, 1053.1532, 29.764413, 26.311729
869, -22.052483, 30.195386, -156.5008
870, -73.64183, 30.916096, -134.82823
871, -132.97084, 31.619961, -101.5175
872, -68.577908, 29.216737, -185.79888
873, 49.934576, 20.012428, -198.69388
874, 68.002947, 24.88272, -162.01049
875, 21.187253, 33.906045, -153.7187
876, 48.06294, 20.265922, -222.94353
877, 108.52544, 29.195205, -246.29469
878, 12.145107, 20.810039, -177.798
879, 70.900563, 30.864643, -222.83083
880, 46.372153, 41.139721, -209.72138
881, 41.424631, 18.535775, -245.4319
882, 14.09004, 17.582088, -271.48476
883, -6.5866156, 18.218721, -271.2457
884, -167.26834, 17.714442, -3.5798924
885, -186.53063, 16.081424, -5.6339487
886, -183.74738, 19.560449, 14.604249
887, 33.734419, 19.121678, 186.56323
888, -197.67825, 18.274209, 47.431405
889, -216.65626, 17.750633, 45.121458
890, -34.457429, 19.946204, -188.43374
891, 43.339936, 40.107153, 199.89656
892, 38.371814, 17.068901, 208.8092
893, 48.92353, 20.815323, 226.01246
894, 44.126667, 39.282281, 219.20669
895, 45.780891, 39.686112, 239.78314
896, 32.394116, 40.686781, 182.72407
897, -52.746497, 29.441903, -256.85933
898, -55.413235, 28.616067, -217.80908
899, -50.007588, 22.701604, -166.94881
900, -131.07902, 29.064959, 204.92438
901, -108.1399, 32.246215, -170.00029
902, 44.344837, 40.508813, -239.7765
903, -4.1899631, 40.960752, -272.50262
904, 31.027647, 34.747532, -269.83191
905, 95.732605, 39.268364, -211.83724
906, 72.604562, 33.977823, -195.37209
907, 54.405526, 39.911528, -178.20207
908, -38.240655, 29.617322, 264.66254
909, 66.641216, 30.374723, -255.4014
910, -26.60948, 28.51026, -271.37276
911, -31.773739, 42.017496, -187.94372
912, 33.225594, 20.479449, -181.53007
913, 32.749901, 41.959381, -187.12572
914, 14.238478, 45.528842, -189.57367
915, -2.3473716, 39.799083, -180.7899
916, -13.674646, 20.868272, -180.56476
917, -162.41316, 17.879803, -109.02414
918, -171.93751, 41.046278, -110.6001
919, -273.25154, 43.54672, -3.2972233
920, -268.55451, 25.715549, -24.966033
921, -181.65437, 36.981834, -8.8972908
922, -186.10398, 41.330013, 11.070866
923, -189.45055, 37.023114, 34.385566
924, -209.10074, 39.135612, 52.39079
925, -270.58487, 33.47777, 22.384694
926, -246.76006, 39.486026, 39.190564
927, -235.03349, 30.796634, 64.557967
928, -204.97537, 24.408847, 75.234854
929, -187.89023, 23.645207, -29.790096
930, -167.2129, 27.043577, 213.85379
931, -116.78288, 24.041436, 137.93098
932, 42.301992, 17.348797, 245.89823
933, -6.0708401, 19.842593, 179.84844
934, 13.484457, 37.821537, 181.58359
935, -56.216977, 32.442231, 197.78795
936, -34.127176, 24.656826, 187.74203
937, -20.544372, 41.217222, 180.4572
938, 42.987379, 29.961498, 266.82394
939, -2.9557403, 40.975105, 181.93425
940, -1.2417348, 42.017044, 163.62746
941, -190.39063, 23.148275, -111.09712
942, -116.90524, 118.84393, -28.591405
*Element, type=C3D4, ELSET=PART1
1, 666, 677, 623, 662
2, 830, 896, 887, 827
3, 540, 920, 491, 499
4, 386, 83, 435, 857
5, 835, 302, 553, 301
6, 782, 865, 920, 770
7, 643, 325, 701, 640
8, 394, 770, 140, 139
9, 920, 540, 773, 499
10, 693, 697, 667, 708
11, 842, 323, 940, 853
12, 920, 773, 540, 772
13, 489, 579, 900, 496
14, 193, 85, 491, 865
15, 832, 836, 295, 868
16, 931, 792, 844, 367
17, 875, 869, 915, 878
18, 772, 919, 540, 920
19, 107, 369, 794, 106
20, 866, 372, 868, 529
21, 395, 228, 227, 547
22, 562, 854, 852, 856
23, 848, 858, 921, 545
24, 935, 486, 838, 839
25, 353, 508, 399, 50
26, 600, 479, 346, 450
27, 868, 296, 866, 548
28, 845, 793, 798, 369
29, 891, 896, 816, 537
30, 204, 904, 493, 205
31, 439, 893, 852, 892
32, 237, 512, 587, 433
33, 384, 841, 936, 933
34, 713, 311, 685, 310
35, 932, 124, 806, 125
36, 486, 837, 935, 838
37, 869, 916, 915, 878
38, 158, 320, 404, 679
39, 798, 849, 845, 369
40, 888, 441, 472, 388
41, 923, 786, 778, 783
42, 838, 523, 524, 592
43, 835, 397, 146, 147
44, 486, 837, 459, 935
45, 837, 524, 838, 900
46, 15, 2, 22, 3
47, 935, 592, 839, 838
48, 234, 347, 514, 245
49, 137, 138, 768, 393
50, 774, 773, 288, 601
51, 888, 786, 923, 763
52, 486, 837, 838, 446
53, 798, 370, 794, 797
54, 309, 846, 923, 848
55, 193, 286, 919, 540
56, 490, 494, 788, 796
57, 215, 268, 49, 216
58, 935, 592, 593, 839
59, 523, 522, 844, 800
60, 547, 295, 836, 868
61, 698, 320, 637, 321
62, 468, 869, 899, 487
63, 319, 159, 679, 681
64, 319, 320, 679, 404
65, 824, 825, 932, 806
66, 837, 610, 935, 838
67, 741, 742, 903, 883
68, 694, 660, 707, 700
69, 932, 124, 805, 806
70, 273, 272, 229, 62
71, 479, 450, 559, 444
72, 212, 250, 249, 40
73, 45, 212, 249, 40
74, 804, 378, 123, 805
75, 285, 919, 925, 193
76, 846, 154, 405, 680
77, 904, 206, 205, 503
78, 267, 116, 49, 268
79, 894, 537, 891, 818
80, 721, 720, 421, 873
81, 680, 858, 405, 848
82, 267, 268, 49, 215
83, 820, 539, 282, 821
84, 308, 846, 845, 591
85, 105, 792, 367, 368
86, 729, 596, 897, 728
87, 303, 510, 834, 509
88, 604, 479, 559, 444
89, 931, 844, 800, 523
90, 362, 583, 502, 201
91, 940, 853, 323, 934
92, 903, 203, 910, 338
93, 642, 650, 624, 691
94, 263, 109, 262, 526
95, 866, 372, 400, 868
96, 694, 660, 641, 669
97, 429, 352, 42, 505
98, 522, 845, 521, 591
99, 682, 635, 702, 681
100, 726, 742, 725, 883
101, 251, 46, 250, 213
102, 845, 798, 799, 521
103, 904, 493, 96, 882
104, 279, 818, 816, 537
105, 444, 319, 404, 559
106, 923, 591, 924, 847
107, 868, 400, 866, 832
108, 868, 296, 832, 866
109, 450, 463, 355, 560
110, 192, 857, 191, 83
111, 942, 705, 629, 654
112, 354, 224, 57, 396
113, 319, 406, 444, 404
114, 109, 120, 373, 263
115, 891, 830, 818, 816
116, 19, 623, 13, 24
117, 822, 377, 804, 826
118, 510, 58, 225, 430
119, 847, 475, 441, 846
120, 41, 518, 249, 211
121, 384, 385, 129, 812
122, 384, 812, 129, 811
123, 942, 654, 710, 705
124, 767, 860, 774, 929
125, 307, 523, 840, 592
126, 391, 84, 925, 865
127, 396, 224, 56, 223
128, 358, 900, 789, 930
129, 880, 618, 879, 573
130, 933, 384, 811, 936
131, 928, 472, 888, 847
132, 798, 521, 256, 799
133, 143, 142, 585, 306
134, 914, 344, 736, 915
135, 623, 677, 24, 19
136, 934, 815, 827, 816
137, 533, 534, 937, 593
138, 847, 452, 845, 928
139, 507, 374, 589, 527
140, 50, 578, 508, 217
141, 236, 432, 511, 235
142, 589, 265, 118, 266
143, 716, 661, 668, 663
144, 847, 452, 475, 845
145, 366, 790, 365, 838
146, 384, 841, 480, 936
147, 840, 523, 931, 838
148, 484, 467, 455, 862
149, 426, 449, 897, 437
150, 840, 839, 843, 325
151, 942, 654, 629, 653
152, 791, 838, 931, 801
153, 699, 638, 637, 715
154, 346, 33, 32, 515
155, 838, 523, 592, 840
156, 515, 479, 346, 600
157, 346, 600, 511, 515
158, 32, 33, 246, 515
159, 303, 302, 509, 833
160, 266, 214, 48, 47
161, 697, 687, 693, 667
162, 942, 653, 710, 654
163, 923, 922, 778, 546
164, 366, 476, 931, 838
165, 496, 253, 261, 803
166, 927, 615, 580, 849
167, 798, 845, 588, 521
168, 551, 60, 585, 227
169, 402, 460, 470, 856
170, 516, 120, 373, 375
171, 231, 230, 64, 431
172, 258, 523, 800, 522
173, 523, 844, 840, 931
174, 643, 688, 712, 701
175, 374, 265, 119, 118
176, 15, 694, 641, 686
177, 615, 928, 924, 591
178, 791, 366, 931, 838
179, 896, 562, 856, 322
180, 873, 876, 739, 880
181, 616, 851, 605, 852
182, 353, 49, 268, 216
183, 281, 280, 538, 819
184, 266, 267, 48, 215
185, 504, 558, 557, 453
186, 857, 391, 83, 925
187, 891, 562, 852, 856
188, 266, 215, 48, 214
189, 896, 323, 934, 535
190, 934, 278, 939, 815
191, 210, 518, 348, 44
192, 835, 397, 553, 509
193, 323, 322, 690, 645
194, 203, 202, 897, 576
195, 819, 280, 538, 818
196, 507, 374, 428, 589
197, 165, 753, 173, 415
198, 894, 825, 892, 893
199, 878, 719, 916, 915
200, 584, 573, 879, 618
201, 818, 891, 816, 537
202, 425, 726, 910, 426
203, 929, 860, 774, 595
204, 397, 396, 833, 146
205, 322, 402, 856, 853
206, 599, 941, 918, 862
207, 637, 708, 667, 636
208, 411, 467, 941, 455
209, 510, 58, 354, 224
210, 908, 241, 184, 75
211, 775, 543, 293, 284
212, 462, 402, 856, 855
213, 322, 402, 855, 856
214, 460, 887, 470, 856
215, 708, 698, 706, 636
216, 935, 610, 837, 532
217, 867, 353, 528, 399
218, 65, 577, 64, 349
219, 867, 353, 399, 114
220, 942, 653, 629, 628
221, 551, 60, 142, 585
222, 299, 508, 218, 150
223, 652, 942, 713, 628
224, 767, 768, 774, 860
225, 455, 393, 392, 860
226, 539, 240, 74, 377
227, 372, 114, 113, 867
228, 424, 363, 882, 180
229, 409, 408, 465, 870
230, 114, 270, 113, 867
231, 391, 386, 131, 780
232, 49, 115, 268, 116
233, 467, 412, 411, 917
234, 270, 269, 867, 114
235, 381, 532, 813, 935
236, 867, 353, 269, 528
237, 758, 330, 582, 757
238, 934, 278, 535, 939
239, 324, 323, 535, 940
240, 270, 528, 867, 269
241, 504, 905, 481, 557
242, 600, 479, 559, 604
243, 318, 453, 874, 557
244, 618, 880, 906, 907
245, 938, 606, 586, 895
246, 760, 567, 332, 333
247, 429, 364, 453, 504
248, 356, 938, 851, 932
249, 857, 391, 386, 83
250, 391, 780, 131, 766
251, 518, 44, 41, 348
252, 250, 212, 46, 40
253, 853, 460, 856, 887
254, 504, 453, 557, 481
255, 48, 117, 266, 47
256, 285, 919, 286, 771
257, 48, 117, 267, 266
258, 485, 873, 481, 469
259, 853, 402, 842, 322
260, 885, 765, 390, 135
261, 308, 154, 844, 846
262, 642, 691, 624, 20
263, 840, 154, 844, 688
264, 649, 710, 653, 670
265, 555, 869, 911, 572
266, 160, 682, 681, 318
267, 96, 97, 205, 904
268, 732, 572, 911, 915
269, 611, 556, 907, 618
270, 445, 512, 561, 854
271, 741, 883, 903, 882
272, 675, 677, 623, 19
273, 624, 642, 20, 18
274, 667, 715, 693, 708
275, 831, 835, 147, 553
276, 881, 363, 724, 904
277, 562, 605, 852, 616
278, 824, 938, 829, 805
279, 830, 894, 891, 818
280, 594, 814, 813, 935
281, 309, 846, 848, 680
282, 830, 894, 892, 891
283, 928, 452, 849, 435
284, 382, 439, 887, 892
285, 484, 455, 392, 862
286, 476, 839, 838, 486
287, 572, 869, 315, 555
288, 858, 884, 405, 848
289, 840, 154, 367, 844
290, 853, 896, 934, 887
291, 391, 766, 925, 780
292, 390, 456, 884, 447
293, 410, 311, 861, 858
294, 400, 399, 866, 832
295, 529, 270, 867, 113
296, 771, 781, 285, 925
297, 647, 624, 668, 695
298, 868, 395, 547, 530
299, 597, 898, 569, 872
300, 20, 19, 675, 17
301, 776, 595, 774, 289
302, 27, 10, 9, 8
303, 864, 862, 941, 599
304, 675, 624, 20, 17
305, 617, 773, 601, 541
306, 423, 474, 477, 898
307, 623, 675, 19, 17
308, 938, 895, 586, 851
309, 307, 688, 840, 844
310, 324, 639, 323, 701
311, 909, 363, 438, 881
312, 474, 362, 477, 898
313, 237, 433, 587, 70
314, 912, 720, 442, 420
315, 18, 20, 624, 17
316, 17, 13, 19, 623
317, 23, 24, 19, 13
318, 553, 55, 222, 397
319, 402, 853, 460, 856
320, 707, 635, 644, 702
321, 506, 352, 43, 348
322, 573, 909, 902, 503
323, 70, 236, 69, 355
324, 14, 23, 19, 13
325, 17, 14, 19, 13
326, 851, 938, 238, 586
327, 755, 198, 752, 89
328, 451, 854, 433, 445
329, 759, 331, 566, 758
330, 511, 450, 355, 560
331, 597, 898, 613, 569
332, 299, 508, 150, 298
333, 683, 869, 315, 316
334, 528, 399, 866, 867
335, 20, 21, 18, 6
336, 642, 20, 18, 6
337, 866, 528, 867, 529
338, 138, 769, 768, 436
339, 275, 813, 531, 532
340, 237, 71, 433, 70
341, 7, 18, 21, 6
342, 616, 851, 586, 605
343, 196, 361, 864, 500
344, 328, 501, 755, 327
345, 675, 691, 20, 624
346, 143, 60, 585, 142
347, 143, 60, 59, 585
348, 60, 226, 59, 585
349, 276, 594, 814, 813
350, 765, 885, 784, 764
351, 890, 419, 468, 418
352, 852, 891, 887, 892
353, 467, 412, 917, 464
354, 181, 726, 883, 425
355, 487, 869, 899, 870
356, 576, 729, 596, 897
357, 468, 869, 890, 899
358, 791, 801, 931, 800
359, 836, 153, 868, 832
360, 884, 858, 921, 848
361, 153, 400, 868, 832
362, 469, 876, 879, 438
363, 911, 916, 915, 869
364, 714, 709, 700, 656
365, 875, 407, 874, 317
366, 737, 916, 890, 419
367, 872, 483, 890, 899
368, 865, 193, 84, 925
369, 259, 802, 524, 260
370, 416, 749, 901, 758
371, 481, 905, 906, 557
372, 683, 682, 875, 316
373, 776, 765, 767, 929
374, 725, 424, 883, 882
375, 443, 423, 898, 723
376, 361, 500, 860, 864
377, 705, 312, 311, 629
378, 855, 854, 488, 445
379, 854, 451, 488, 445
380, 643, 716, 712, 663
381, 796, 803, 930, 788
382, 473, 929, 484, 392
383, 361, 500, 436, 860
384, 840, 839, 476, 843
385, 837, 495, 579, 434
386, 901, 759, 566, 758
387, 888, 441, 847, 472
388, 523, 838, 801, 931
389, 887, 896, 934, 827
390, 866, 614, 549, 550
391, 865, 782, 919, 925
392, 739, 735, 744, 913
393, 704, 313, 630, 631
394, 614, 528, 399, 866
395, 104, 792, 791, 931
396, 928, 435, 849, 927
397, 758, 417, 750, 757
398, 287, 540, 772, 286
399, 545, 777, 922, 291
400, 522, 258, 257, 800
401, 915, 875, 914, 575
402, 416, 758, 417, 750
403, 371, 113, 112, 271
404, 396, 224, 57, 56
405, 549, 528, 614, 866
406, 108, 795, 794, 370
407, 435, 580, 359, 849
408, 829, 378, 73, 377
409, 900, 77, 489, 358
410, 875, 914, 913, 878
411, 441, 846, 923, 847
412, 240, 829, 73, 377
413, 384, 129, 128, 811
414, 522, 308, 845, 591
415, 457, 482, 878, 448
416, 872, 483, 443, 890
417, 532, 610, 594, 935
418, 357, 837, 434, 495
419, 908, 813, 808, 381
420, 935, 532, 454, 381
421, 837, 935, 532, 454
422, 839, 936, 459, 480
423, 933, 828, 810, 827
424, 938, 606, 513, 586
425, 875, 912, 878, 913
426, 495, 908, 357, 532
427, 588, 798, 520, 497
428, 935, 814, 813, 812
429, 908, 813, 531, 823
430, 923, 309, 848, 546
431, 550, 614, 399, 866
432, 543, 926, 850, 927
433, 441, 763, 134, 388
434, 385, 936, 459, 935
435, 763, 786, 923, 783
436, 28, 6, 687, 5
437, 626, 680, 713, 712
438, 781, 285, 925, 590
439, 285, 919, 771, 925
440, 500, 86, 87, 436
441, 925, 780, 766, 785
442, 797, 798, 497, 520
443, 325, 307, 840, 592
444, 196, 361, 88, 864
445, 942, 311, 713, 628
446, 762, 850, 889, 786
447, 677, 666, 718, 662
448, 484, 929, 861, 862
449, 319, 406, 558, 444
450, 676, 10, 16, 621
451, 313, 409, 684, 871
452, 929, 595, 544, 861
453, 410, 311, 312, 861
454, 174, 737, 723, 443
455, 309, 680, 848, 310
456, 898, 570, 613, 569
457, 490, 796, 788, 795
458, 309, 627, 713, 310
459, 407, 408, 875, 457
460, 749, 169, 750, 416
461, 903, 571, 904, 204
462, 680, 858, 848, 310
463, 180, 363, 882, 724
464, 929, 885, 921, 784
465, 313, 705, 312, 684
466, 752, 751, 90, 492
467, 336, 738, 569, 570
468, 680, 713, 685, 310
469, 898, 502, 596, 897
470, 842, 402, 156, 690
471, 715, 716, 701, 648
472, 426, 94, 437, 897
473, 474, 502, 898, 897
474, 845, 793, 799, 798
475, 740, 880, 734, 739
476, 584, 879, 905, 618
477, 490, 494, 79, 788
478, 763, 888, 388, 441
479, 236, 237, 587, 70
480, 445, 463, 587, 355
481, 88, 864, 361, 415
482, 511, 236, 587, 355
483, 236, 432, 355, 511
484, 416, 565, 901, 597
485, 550, 297, 832, 151
486, 154, 846, 475, 844
487, 562, 896, 323, 322
488, 443, 737, 418, 174
489, 626, 664, 625, 712
490, 813, 275, 531, 823
491, 688, 325, 643, 307
492, 823, 598, 531, 908
493, 814, 828, 936, 937
494, 544, 545, 921, 858
495, 496, 187, 489, 186
496, 909, 363, 97, 438
497, 358, 78, 77, 489
498, 852, 851, 893, 451
499, 391, 766, 131, 140
500, 571, 904, 205, 609
501, 677, 666, 710, 718
502, 207, 877, 584, 206
503, 412, 871, 413, 747
504, 809, 383, 810, 827
505, 610, 594, 935, 593
506, 937, 940, 939, 933
507, 296, 549, 832, 866
508, 109, 263, 373, 526
509, 515, 479, 345, 346
510, 714, 671, 700, 707
511, 8, 621, 646, 692
512, 671, 714, 700, 657
513, 842, 322, 402, 690
514, 251, 46, 39, 250
515, 298, 297, 550, 151
516, 749, 748, 168, 414
517, 656, 646, 709, 700
518, 872, 901, 602, 597
519, 46, 507, 351, 47
520, 46, 507, 251, 351
521, 699, 638, 321, 637
522, 760, 748, 759, 901
523, 32, 247, 345, 515
524, 848, 884, 458, 886
525, 842, 853, 940, 841
526, 620, 660, 674, 700
527, 757, 751, 756, 492
528, 91, 757, 492, 751
529, 324, 842, 940, 841
530, 624, 650, 668, 695
531, 652, 942, 710, 713
532, 737, 916, 732, 890
533, 394, 920, 139, 360
534, 924, 786, 888, 889
535, 869, 555, 870, 315
536, 495, 76, 184, 185
537, 652, 942, 653, 710
538, 435, 452, 461, 928
539, 584, 905, 557, 618
540, 627, 628, 652, 713
541, 837, 524, 610, 838
542, 710, 666, 649, 652
543, 865, 394, 84, 85
544, 718, 664, 651, 712
545, 710, 649, 653, 652
546, 752, 89, 415, 755
547, 402, 157, 156, 690
548, 209, 210, 506, 43
549, 568, 761, 918, 326
550, 740, 880, 902, 734
551, 226, 430, 59, 585
552, 556, 907, 557, 317
553, 884, 447, 458, 886
554, 795, 490, 79, 788
555, 686, 15, 3, 641
556, 697, 672, 667, 708
557, 650, 693, 715, 695
558, 297, 550, 832, 549
559, 749, 759, 901, 758
560, 869, 870, 408, 683
561, 745, 740, 722, 881
562, 657, 620, 656, 700
563, 871, 918, 863, 564
564, 650, 648, 668, 695
565, 870, 760, 313, 567
566, 884, 885, 447, 886
567, 825, 819, 895, 894
568, 436, 491, 86, 360
569, 72, 938, 356, 379
570, 710, 677, 696, 649
571, 98, 364, 877, 438
572, 720, 873, 739, 912
573, 808, 908, 822, 823
574, 820, 539, 513, 282
575, 438, 364, 877, 481
576, 687, 6, 20, 642
577, 904, 731, 745, 733
578, 319, 644, 706, 636
579, 905, 504, 481, 877
580, 126, 380, 892, 807
581, 615, 927, 580, 498
582, 380, 126, 892, 439
583, 884, 885, 886, 921
584, 153, 400, 398, 868
585, 439, 893, 451, 852
586, 378, 804, 123, 377
587, 804, 122, 123, 377
588, 439, 893, 380, 451
589, 848, 884, 886, 921
590, 230, 229, 63, 273
591, 573, 341, 902, 734
592, 577, 232, 36, 65
593, 876, 740, 880, 902
594, 529, 528, 549, 866
595, 504, 429, 558, 453
596, 729, 576, 910, 897
597, 389, 764, 135, 134
598, 134, 886, 764, 763
599, 864, 88, 197, 415
600, 396, 834, 833, 145
601, 914, 878, 744, 913
602, 675, 691, 624, 695
603, 516, 120, 263, 373
604, 232, 66, 36, 65
605, 576, 203, 910, 897
606, 650, 691, 695, 624
607, 588, 845, 849, 591
608, 78, 358, 101, 930
609, 879, 584, 905, 877
610, 240, 829, 513, 938
611, 723, 423, 174, 443
612, 274, 275, 823, 531
613, 76, 357, 184, 75
614, 433, 445, 587, 355
615, 731, 903, 904, 741
616, 846, 845, 475, 844
617, 716, 661, 663, 643
618, 443, 737, 890, 418
619, 781, 771, 785, 925
620, 519, 80, 497, 797
621, 351, 507, 428, 47
622, 732, 738, 743, 911
623, 573, 342, 341, 734
624, 374, 375, 527, 351
625, 759, 566, 332, 901
626, 357, 908, 381, 532
627, 590, 857, 925, 926
628, 720, 177, 442, 420
629, 321, 403, 855, 402
630, 889, 461, 388, 888
631, 435, 580, 82, 359
632, 762, 850, 859, 889
633, 376, 808, 908, 822
634, 898, 570, 596, 613
635, 526, 349, 516, 373
636, 903, 203, 493, 910
637, 896, 891, 887, 856
638, 510, 58, 224, 225
639, 879, 876, 902, 909
640, 879, 880, 902, 876
641, 384, 841, 440, 480
642, 324, 325, 843, 839
643, 573, 879, 902, 909
644, 615, 588, 849, 591
645, 16, 621, 10, 8
646, 904, 741, 903, 882
647, 721, 876, 421, 422
648, 415, 941, 864, 361
649, 835, 397, 147, 553
650, 729, 903, 742, 910
651, 112, 371, 271, 530
652, 426, 726, 182, 425
653, 98, 438, 877, 909
654, 415, 941, 753, 864
655, 895, 605, 851, 894
656, 89, 198, 501, 755
657, 573, 880, 902, 879
658, 583, 417, 565, 582
659, 493, 904, 96, 205
660, 749, 169, 414, 168
661, 911, 916, 732, 915
662, 27, 16, 26, 10
663, 737, 898, 743, 723
664, 381, 813, 532, 908
665, 844, 368, 845, 475
666, 572, 869, 915, 316
667, 676, 10, 26, 16
668, 801, 523, 931, 800
669, 873, 720, 421, 442
670, 907, 556, 913, 875
671, 904, 909, 902, 881
672, 396, 223, 509, 510
673, 92, 583, 201, 200
674, 170, 417, 750, 416
675, 782, 925, 766, 785
676, 417, 757, 751, 750
677, 171, 751, 90, 172
678, 474, 502, 362, 898
679, 94, 493, 910, 95
680, 904, 909, 503, 902
681, 383, 887, 934, 827
682, 682, 407, 875, 317
683, 179, 422, 881, 722
684, 506, 210, 348, 43
685, 467, 484, 863, 862
686, 938, 895, 851, 932
687, 765, 885, 764, 135
688, 782, 865, 766, 925
689, 329, 330, 757, 582
690, 410, 311, 685, 312
691, 422, 179, 178, 722
692, 904, 206, 97, 205
693, 880, 879, 906, 873
694, 522, 308, 307, 844
695, 137, 768, 767, 393
696, 296, 832, 295, 868
697, 231, 232, 577, 65
698, 878, 912, 744, 913
699, 735, 880, 913, 739
700, 353, 508, 578, 614
701, 11, 622, 676, 25
702, 611, 556, 913, 907
703, 496, 579, 186, 489
704, 938, 824, 895, 932
705, 912, 739, 744, 913
706, 934, 933, 827, 939
707, 880, 873, 913, 739
708, 380, 807, 893, 892
709, 873, 912, 913, 739
710, 772, 773, 769, 920
711, 436, 491, 499, 86
712, 928, 889, 924, 888
713, 461, 472, 388, 888
714, 859, 889, 387, 762
715, 519, 80, 189, 497
716, 58, 226, 225, 430
717, 253, 188, 796, 494
718, 254, 188, 796, 253
719, 188, 490, 796, 494
720, 520, 797, 255, 519
721, 731, 904, 609, 733
722, 731, 903, 741, 730
723, 573, 618, 608, 880
724, 893, 932, 806, 125
725, 851, 852, 893, 894
726, 792, 105, 367, 104
727, 895, 538, 894, 819
728, 699, 715, 701, 648
729, 895, 538, 605, 894
730, 852, 605, 894, 851
731, 753, 754, 941, 746
732, 79, 78, 101, 930
733, 92, 417, 200, 91
734, 914, 344, 343, 736
735, 682, 635, 634, 702
736, 910, 727, 897, 426
737, 819, 538, 894, 818
738, 99, 429, 42, 208
739, 224, 58, 354, 57
740, 583, 417, 200, 92
741, 920, 540, 491, 919
742, 85, 920, 360, 491
743, 936, 814, 533, 935
744, 107, 369, 370, 794
745, 338, 204, 339, 903
746, 793, 105, 106, 368
747, 929, 776, 921, 544
748, 822, 377, 122, 804
749, 887, 853, 383, 934
750, 672, 694, 707, 697
751, 545, 544, 921, 290
752, 617, 499, 773, 541
753, 544, 776, 921, 290
754, 308, 688, 712, 625
755, 847, 452, 472, 475
756, 781, 926, 925, 785
757, 525, 803, 802, 900
758, 846, 308, 845, 844
759, 688, 643, 712, 625
760, 81, 190, 497, 359
761, 490, 797, 796, 795
762, 462, 402, 470, 856
763, 784, 885, 921, 886
764, 473, 929, 390, 456
765, 672, 708, 706, 636
766, 627, 309, 713, 626
767, 45, 41, 249, 211
768, 457, 448, 878, 420
769, 798, 849, 588, 845
770, 672, 694, 641, 669
771, 699, 690, 645, 701
772, 119, 527, 375, 264
773, 928, 591, 847, 924
774, 597, 477, 898, 872
775, 729, 903, 910, 338
776, 857, 391, 780, 386
777, 590, 857, 192, 925
778, 689, 401, 155, 156
779, 926, 859, 850, 927
780, 926, 859, 787, 850
781, 154, 164, 405, 680
782, 926, 780, 787, 859
783, 926, 780, 785, 787
784, 908, 241, 536, 598
785, 798, 588, 256, 521
786, 908, 495, 531, 532
787, 780, 925, 857, 926
788, 896, 934, 827, 816
789, 423, 727, 898, 723
790, 626, 308, 712, 625
791, 748, 413, 168, 414
792, 870, 465, 487, 408
793, 602, 872, 870, 901
794, 468, 890, 418, 483
795, 16, 692, 8, 674
796, 926, 925, 785, 780
797, 600, 479, 604, 517
798, 181, 726, 725, 883
799, 716, 643, 712, 701
800, 832, 399, 152, 400
801, 45, 44, 41, 211
802, 113, 372, 867, 529
803, 296, 868, 295, 548
804, 153, 400, 832, 152
805, 497, 359, 580, 849
806, 717, 657, 714, 703
807, 532, 357, 454, 381
808, 903, 203, 204, 493
809, 228, 427, 530, 395
810, 397, 509, 222, 553
811, 529, 868, 866, 548
812, 895, 605, 586, 851
813, 694, 672, 707, 669
814, 49, 48, 267, 215
815, 828, 933, 936, 937
816, 873, 485, 874, 912
817, 815, 534, 939, 937
818, 709, 692, 700, 646
819, 457, 407, 874, 875
820, 793, 845, 368, 369
821, 762, 850, 787, 859
822, 874, 485, 481, 453
823, 86, 85, 360, 491
824, 700, 646, 620, 656
825, 665, 639, 701, 648
826, 878, 912, 457, 420
827, 592, 839, 838, 840
828, 485, 873, 874, 481
829, 922, 923, 783, 886
830, 72, 938, 239, 238
831, 364, 504, 481, 453
832, 926, 775, 543, 850
833, 886, 441, 458, 848
834, 457, 875, 874, 912
835, 447, 886, 885, 764
836, 922, 923, 778, 783
837, 922, 784, 921, 886
838, 89, 752, 415, 173
839, 16, 674, 8, 1
840, 540, 193, 194, 491
841, 418, 737, 175, 174
842, 903, 571, 731, 904
843, 884, 456, 405, 458
844, 160, 407, 682, 318
845, 286, 771, 919, 772
846, 336, 738, 570, 728
847, 705, 312, 685, 311
848, 243, 66, 233, 35
849, 169, 170, 750, 416
850, 594, 276, 532, 813
851, 660, 694, 707, 669
852, 566, 602, 332, 901
853, 931, 104, 367, 366
854, 380, 851, 451, 893
855, 854, 562, 852, 616
856, 924, 607, 615, 591
857, 904, 731, 609, 571
858, 853, 896, 887, 856
859, 671, 660, 707, 669
860, 589, 265, 527, 374
861, 659, 671, 714, 707
862, 671, 659, 669, 707
863, 854, 561, 855, 562
864, 552, 54, 831, 148
865, 142, 395, 294, 141
866, 938, 356, 379, 932
867, 312, 163, 410, 871
868, 562, 561, 616, 854
869, 49, 117, 267, 48
870, 672, 697, 707, 708
871, 134, 886, 389, 764
872, 562, 896, 537, 535
873, 236, 432, 69, 355
874, 353, 268, 578, 216
875, 828, 933, 939, 827
876, 485, 457, 874, 912
877, 5, 6, 687, 642
878, 408, 457, 482, 875
879, 933, 940, 841, 937
880, 683, 870, 162, 684
881, 876, 438, 909, 879
882, 782, 920, 772, 769
883, 99, 877, 364, 504
884, 448, 719, 419, 916
885, 873, 879, 876, 880
886, 903, 571, 339, 731
887, 565, 362, 417, 583
888, 898, 502, 613, 596
889, 49, 116, 267, 117
890, 784, 922, 783, 886
891, 596, 570, 728, 337
892, 743, 890, 911, 898
893, 714, 659, 707, 702
894, 743, 732, 911, 890
895, 890, 732, 737, 743
896, 519, 80, 797, 490
897, 859, 889, 850, 927
898, 856, 439, 852, 887
899, 644, 319, 706, 681
900, 890, 869, 911, 899
901, 659, 714, 658, 702
902, 468, 916, 890, 869
903, 313, 409, 870, 684
904, 632, 633, 703, 315
905, 544, 929, 861, 858
906, 644, 672, 707, 706
907, 916, 419, 448, 482
908, 864, 500, 581, 196
909, 598, 908, 817, 536
910, 522, 523, 844, 307
911, 15, 686, 3, 30
912, 864, 599, 563, 581
913, 911, 916, 890, 732
914, 911, 916, 869, 890
915, 611, 880, 913, 574
916, 599, 918, 563, 564
917, 736, 732, 719, 915
918, 707, 635, 669, 644
919, 471, 899, 872, 870
920, 672, 697, 619, 641
921, 155, 688, 843, 689
922, 346, 511, 450, 432
923, 732, 916, 719, 915
924, 713, 626, 712, 651
925, 924, 786, 923, 888
926, 908, 826, 817, 536
927, 924, 786, 779, 923
928, 368, 452, 845, 475
929, 786, 850, 779, 787
930, 863, 467, 464, 410
931, 595, 776, 544, 289
932, 680, 858, 685, 164
933, 320, 158, 678, 679
934, 506, 479, 517, 604
935, 543, 924, 779, 607
936, 927, 615, 924, 543
937, 856, 439, 488, 852
938, 927, 615, 543, 498
939, 927, 859, 857, 926
940, 133, 889, 762, 387
941, 522, 257, 521, 799
942, 461, 889, 388, 387
943, 900, 77, 579, 489
944, 793, 369, 794, 798
945, 936, 841, 480, 839
946, 797, 80, 795, 490
947, 797, 80, 497, 370
948, 457, 912, 442, 420
949, 620, 692, 700, 674
950, 692, 620, 700, 646
951, 207, 584, 877, 504
952, 797, 370, 795, 80
953, 127, 809, 382, 383
954, 933, 841, 936, 937
955, 649, 622, 696, 621
956, 911, 335, 732, 738
957, 898, 597, 613, 502
958, 798, 370, 797, 497
959, 493, 883, 910, 95
960, 888, 889, 763, 388
961, 742, 730, 741, 903
962, 743, 569, 898, 911
963, 621, 622, 696, 676
964, 416, 758, 565, 417
965, 34, 67, 35, 244
966, 705, 704, 684, 313
967, 870, 760, 413, 313
968, 326, 761, 334, 568
969, 929, 456, 858, 884
970, 455, 467, 941, 862
971, 89, 501, 197, 415
972, 760, 759, 332, 901
973, 942, 311, 705, 713
974, 204, 904, 205, 571
975, 864, 754, 941, 753
976, 743, 898, 570, 728
977, 484, 929, 862, 392
978, 545, 777, 921, 922
979, 313, 312, 871, 684
980, 390, 765, 136, 135
981, 929, 774, 776, 595
982, 473, 929, 392, 136
983, 67, 66, 35, 233
984, 857, 391, 925, 780
985, 809, 382, 887, 892
986, 591, 607, 923, 924
987, 126, 439, 382, 892
988, 881, 724, 745, 904
989, 347, 67, 234, 68
990, 776, 765, 929, 784
991, 845, 588, 521, 591
992, 441, 763, 923, 886
993, 936, 533, 937, 593
994, 347, 33, 514, 245
995, 593, 936, 839, 937
996, 920, 919, 782, 772
997, 652, 942, 628, 653
998, 848, 309, 310, 546
999, 940, 933, 934, 939
1000, 934, 933, 383, 827
1001, 308, 522, 845, 844
1002, 383, 809, 382, 887
1003, 940, 933, 853, 934
1004, 876, 438, 881, 909
1005, 896, 562, 323, 535
1006, 934, 933, 853, 383
1007, 356, 433, 851, 238
1008, 511, 560, 355, 587
1009, 438, 876, 422, 469
1010, 649, 621, 696, 670
1011, 212, 45, 249, 211
1012, 798, 370, 369, 794
1013, 676, 621, 692, 696
1014, 3, 15, 1, 641
1015, 815, 828, 939, 827
1016, 933, 828, 936, 811
1017, 399, 50, 508, 51
1018, 586, 938, 238, 239
1019, 15, 660, 1, 641
1020, 831, 54, 552, 553
1021, 831, 301, 553, 552
1022, 488, 856, 855, 462
1023, 64, 373, 526, 431
1024, 842, 478, 853, 841
1025, 431, 273, 230, 63
1026, 276, 594, 533, 814
1027, 109, 262, 526, 431
1028, 820, 819, 895, 824
1029, 633, 703, 658, 657
1030, 829, 539, 240, 513
1031, 321, 561, 855, 463
1032, 431, 273, 262, 230
1033, 376, 808, 381, 908
1034, 540, 286, 919, 772
1035, 110, 111, 273, 63
1036, 100, 795, 79, 788
1037, 102, 900, 790, 789
1038, 908, 357, 376, 75
1039, 781, 787, 926, 785
1040, 674, 620, 8, 1
1041, 540, 193, 491, 919
1042, 89, 752, 173, 172
1043, 500, 87, 195, 196
1044, 649, 677, 666, 710
1045, 764, 784, 783, 886
1046, 361, 500, 87, 436
1047, 787, 781, 926, 775
1048, 802, 525, 524, 260
1049, 908, 377, 826, 74
1050, 865, 84, 394, 391
1051, 318, 407, 874, 453
1052, 826, 908, 74, 241
1053, 842, 689, 156, 401
1054, 880, 573, 902, 734
1055, 122, 121, 376, 822
1056, 875, 907, 874, 912
1057, 391, 865, 925, 766
1058, 734, 740, 733, 902
1059, 413, 313, 760, 871
1060, 920, 865, 491, 85
1061, 848, 441, 923, 886
1062, 865, 920, 491, 919
1063, 193, 865, 491, 919
1064, 455, 393, 860, 436
1065, 195, 499, 194, 491
1066, 837, 495, 532, 610
1067, 164, 858, 405, 680
1068, 41, 45, 249, 40
1069, 277, 937, 534, 815
1070, 83, 391, 84, 925
1071, 61, 427, 62, 228
1072, 276, 814, 533, 277
1073, 277, 937, 533, 534
1074, 188, 254, 796, 519
1075, 278, 534, 535, 939
1076, 910, 883, 425, 95
1077, 193, 865, 84, 85
1078, 912, 720, 878, 744
1079, 437, 202, 502, 897
1080, 347, 234, 514, 68
1081, 182, 726, 181, 425
1082, 290, 776, 921, 777
1083, 849, 370, 497, 359
1084, 903, 203, 338, 204
1085, 188, 490, 189, 519
1086, 906, 874, 907, 873
1087, 474, 502, 437, 362
1088, 720, 873, 912, 442
1089, 869, 408, 482, 875
1090, 879, 438, 909, 877
1091, 471, 901, 870, 872
1092, 93, 362, 437, 502
1093, 93, 362, 502, 201
1094, 680, 309, 713, 310
1095, 457, 485, 874, 407
1096, 854, 512, 851, 433
1097, 855, 463, 403, 321
1098, 942, 311, 629, 705
1099, 237, 512, 433, 238
1100, 854, 851, 616, 852
1101, 72, 356, 238, 71
1102, 929, 473, 390, 136
1103, 218, 52, 150, 51
1104, 846, 441, 405, 475
1105, 797, 794, 795, 370
1106, 533, 594, 593, 935
1107, 219, 220, 552, 53
1108, 851, 938, 356, 238
1109, 210, 518, 44, 211
1110, 508, 218, 150, 51
1111, 692, 621, 16, 8
1112, 15, 2, 3, 1
1113, 417, 582, 200, 91
1114, 672, 708, 707, 706
1115, 52, 218, 150, 299
1116, 463, 561, 587, 560
1117, 27, 16, 10, 8
1118, 572, 869, 316, 315
1119, 809, 126, 382, 892
1120, 390, 929, 884, 456
1121, 490, 188, 796, 519
1122, 516, 120, 264, 263
1123, 24, 622, 623, 12
1124, 809, 383, 827, 887
1125, 17, 675, 647, 623
1126, 931, 792, 367, 104
1127, 126, 809, 807, 892
1128, 828, 815, 939, 937
1129, 383, 127, 810, 128
1130, 622, 677, 676, 25
1131, 31, 517, 345, 247
1132, 151, 508, 150, 51
1133, 549, 550, 832, 866
1134, 300, 299, 219, 52
1135, 72, 938, 238, 356
1136, 835, 397, 833, 146
1137, 517, 31, 348, 518
1138, 936, 384, 811, 812
1139, 688, 308, 307, 625
1140, 809, 127, 810, 383
1141, 846, 405, 848, 680
1142, 345, 517, 31, 348
1143, 450, 320, 560, 559
1144, 837, 446, 454, 434
1145, 524, 523, 838, 801
1146, 99, 877, 98, 364
1147, 858, 164, 410, 685
1148, 385, 130, 129, 812
1149, 709, 654, 670, 673
1150, 740, 745, 733, 902
1151, 506, 518, 517, 348
1152, 506, 517, 345, 348
1153, 766, 865, 140, 391
1154, 942, 705, 710, 713
1155, 217, 218, 508, 51
1156, 445, 512, 854, 433
1157, 683, 314, 870, 684
1158, 627, 628, 713, 310
1159, 820, 539, 829, 513
1160, 770, 865, 140, 766
1161, 876, 721, 740, 722
1162, 220, 553, 552, 54
1163, 923, 292, 546, 778
1164, 647, 662, 623, 711
1165, 837, 524, 579, 610
1166, 466, 872, 471, 477
1167, 402, 322, 855, 321
1168, 573, 342, 734, 608
1169, 357, 908, 184, 75
1170, 440, 401, 480, 841
1171, 763, 783, 923, 886
1172, 539, 829, 240, 377
1173, 737, 419, 175, 719
1174, 908, 377, 822, 826
1175, 803, 789, 930, 788
1176, 539, 826, 829, 377
1177, 826, 539, 74, 377
1178, 826, 804, 829, 377
1179, 241, 908, 74, 75
1180, 296, 549, 866, 548
1181, 353, 578, 528, 614
1182, 88, 89, 197, 415
1183, 907, 880, 611, 618
1184, 905, 879, 906, 618
1185, 599, 595, 862, 554
1186, 436, 491, 920, 499
1187, 499, 920, 436, 773
1188, 80, 108, 370, 795
1189, 524, 900, 802, 838
1190, 865, 782, 766, 770
1191, 149, 52, 150, 299
1192, 499, 540, 194, 491
1193, 687, 642, 667, 619
1194, 402, 322, 321, 690
1195, 680, 858, 310, 685
1196, 660, 620, 674, 1
1197, 322, 699, 321, 690
1198, 506, 479, 345, 517
1199, 463, 561, 560, 321
1200, 97, 909, 98, 206
1201, 561, 463, 587, 445
1202, 807, 125, 893, 806
1203, 132, 859, 387, 762
1204, 667, 687, 619, 697
1205, 688, 325, 689, 701
1206, 942, 311, 628, 629
1207, 408, 683, 162, 161
1208, 429, 505, 558, 444
1209, 353, 508, 50, 578
1210, 452, 435, 359, 849
1211, 688, 155, 843, 840
1212, 242, 516, 577, 349
1213, 407, 682, 875, 161
1214, 875, 915, 316, 575
1215, 160, 407, 161, 682
1216, 506, 479, 352, 345
1217, 79, 108, 795, 100
1218, 78, 358, 930, 489
1219, 692, 620, 8, 674
1220, 515, 479, 517, 345
1221, 489, 358, 930, 900
1222, 396, 397, 509, 222
1223, 708, 672, 667, 636
1224, 428, 589, 118, 266
1225, 413, 412, 747, 167
1226, 699, 715, 637, 698
1227, 687, 693, 667, 642
1228, 495, 908, 531, 184
1229, 65, 577, 349, 36
1230, 213, 212, 46, 250
1231, 693, 650, 667, 642
1232, 67, 34, 234, 244
1233, 647, 675, 711, 623
1234, 119, 527, 374, 375
1235, 495, 357, 184, 76
1236, 495, 908, 184, 357
1237, 824, 825, 895, 932
1238, 667, 715, 650, 693
1239, 662, 677, 623, 711
1240, 817, 826, 821, 536
1241, 89, 501, 198, 197
1242, 518, 210, 348, 506
1243, 941, 863, 862, 467
1244, 938, 240, 239, 513
1245, 914, 344, 575, 343
1246, 343, 914, 603, 575
1247, 603, 735, 914, 343
1248, 735, 603, 913, 574
1249, 694, 686, 697, 641
1250, 901, 465, 870, 413
1251, 515, 479, 600, 517
1252, 97, 909, 438, 98
1253, 353, 49, 115, 268
1254, 904, 206, 909, 97
1255, 99, 877, 207, 98
1256, 870, 413, 465, 409
1257, 628, 713, 310, 311
1258, 880, 735, 734, 739
1259, 741, 724, 904, 745
1260, 376, 808, 121, 381
1261, 724, 741, 904, 882
1262, 689, 401, 843, 155
1263, 786, 889, 763, 888
1264, 599, 862, 918, 564
1265, 735, 736, 914, 343
1266, 683, 408, 162, 870
1267, 361, 455, 860, 436
1268, 399, 550, 832, 151
1269, 146, 396, 833, 145
1270, 396, 224, 510, 354
1271, 814, 815, 828, 937
1272, 548, 868, 547, 530
1273, 490, 80, 795, 79
1274, 731, 340, 609, 571
1275, 80, 81, 497, 370
1276, 386, 859, 780, 857
1277, 544, 858, 861, 311
1278, 551, 395, 227, 547
1279, 738, 743, 570, 728
1280, 413, 748, 901, 414
1281, 567, 314, 313, 870
1282, 782, 771, 919, 925
1283, 461, 927, 928, 889
1284, 396, 834, 145, 354
1285, 396, 510, 834, 354
1286, 417, 583, 200, 582
1287, 434, 77, 76, 185
1288, 737, 419, 418, 175
1289, 724, 363, 882, 904
1290, 556, 875, 317, 316
1291, 908, 598, 531, 184
1292, 144, 834, 354, 145
1293, 354, 304, 834, 144
1294, 837, 524, 900, 579
1295, 186, 489, 579, 185
1296, 151, 298, 150, 508
1297, 837, 495, 610, 579
1298, 500, 86, 195, 87
1299, 617, 500, 436, 499
1300, 666, 664, 651, 718
1301, 567, 602, 870, 901
1302, 661, 716, 668, 665
1303, 500, 86, 499, 195
1304, 102, 900, 365, 790
1305, 854, 451, 433, 851
1306, 102, 900, 358, 365
1307, 900, 837, 365, 838
1308, 212, 45, 46, 40
1309, 159, 158, 404, 679
1310, 434, 837, 365, 900
1311, 395, 836, 141, 398
1312, 868, 295, 548, 547
1313, 319, 320, 404, 559
1314, 158, 157, 403, 678
1315, 742, 883, 910, 903
1316, 600, 346, 511, 450
1317, 262, 231, 526, 431
1318, 529, 270, 528, 867
1319, 489, 77, 579, 185
1320, 430, 143, 59, 585
1321, 349, 516, 350, 242
1322, 868, 529, 530, 548
1323, 941, 863, 467, 917
1324, 134, 886, 441, 389
1325, 688, 840, 843, 325
1326, 46, 507, 213, 251
1327, 230, 64, 431, 63
1328, 242, 37, 350, 349
1329, 938, 829, 73, 240
1330, 938, 586, 513, 239
1331, 798, 797, 255, 520
1332, 17, 675, 624, 647
1333, 791, 366, 104, 931
1334, 791, 366, 103, 104
1335, 254, 797, 796, 519
1336, 379, 938, 378, 73
1337, 716, 663, 711, 718
1338, 753, 864, 755, 415
1339, 934, 278, 816, 535
1340, 187, 188, 253, 494
1341, 699, 690, 678, 321
1342, 911, 872, 899, 555
1343, 507, 252, 351, 527
1344, 119, 527, 265, 374
1345, 648, 639, 701, 645
1346, 859, 435, 927, 857
1347, 934, 940, 939, 535
1348, 252, 507, 351, 251
1349, 251, 46, 351, 39
1350, 38, 252, 351, 251
1351, 39, 38, 351, 251
1352, 46, 507, 47, 213
1353, 934, 323, 940, 535
1354, 518, 31, 248, 517
1355, 908, 826, 536, 241
1356, 859, 435, 387, 927
1357, 859, 435, 386, 387
1358, 859, 435, 857, 386
1359, 868, 372, 398, 371
1360, 648, 716, 668, 695
1361, 675, 647, 711, 695
1362, 797, 490, 796, 519
1363, 868, 400, 398, 372
1364, 431, 273, 110, 262
1365, 940, 534, 939, 535
1366, 836, 395, 294, 547
1367, 866, 372, 867, 399
1368, 549, 529, 866, 548
1369, 529, 372, 867, 866
1370, 836, 395, 868, 398
1371, 935, 486, 839, 459
1372, 58, 226, 430, 59
1373, 423, 727, 449, 898
1374, 498, 857, 191, 192
1375, 765, 929, 390, 136
1376, 815, 534, 278, 939
1377, 888, 441, 923, 847
1378, 479, 352, 444, 604
1379, 412, 871, 464, 413
1380, 590, 857, 498, 192
1381, 295, 836, 294, 547
1382, 427, 371, 112, 530
1383, 560, 463, 355, 587
1384, 682, 875, 316, 317
1385, 410, 409, 464, 871
1386, 409, 408, 870, 162
1387, 551, 142, 306, 585
1388, 545, 848, 310, 546
1389, 331, 566, 758, 565
1390, 699, 648, 701, 645
1391, 551, 60, 395, 142
1392, 331, 330, 565, 758
1393, 582, 756, 757, 329
1394, 144, 430, 305, 143
1395, 737, 898, 890, 743
1396, 938, 379, 805, 932
1397, 876, 438, 422, 881
1398, 556, 875, 575, 913
1399, 911, 335, 572, 732
1400, 824, 938, 805, 932
1401, 396, 223, 56, 222
1402, 430, 225, 510, 305
1403, 505, 352, 604, 444
1404, 430, 226, 225, 305
1405, 50, 217, 508, 51
1406, 604, 444, 559, 558
1407, 873, 421, 469, 442
1408, 876, 422, 469, 421
1409, 208, 99, 504, 207
1410, 259, 802, 801, 524
1411, 429, 208, 505, 42
1412, 525, 803, 261, 802
1413, 545, 922, 848, 546
1414, 869, 683, 875, 316
1415, 603, 735, 913, 914
1416, 318, 453, 558, 406
1417, 869, 875, 915, 316
1418, 633, 703, 315, 316
1419, 325, 840, 307, 688
1420, 869, 555, 899, 870
1421, 682, 683, 703, 316
1422, 314, 555, 315, 870
1423, 66, 243, 36, 35
1424, 539, 826, 821, 829
1425, 932, 124, 379, 805
1426, 934, 278, 815, 816
1427, 485, 873, 442, 912
1428, 804, 378, 829, 377
1429, 814, 936, 811, 812
1430, 935, 594, 532, 813
1431, 328, 198, 756, 755
1432, 114, 372, 399, 867
1433, 501, 754, 327, 563
1434, 831, 835, 553, 301
1435, 510, 396, 834, 509
1436, 371, 529, 271, 530
1437, 543, 779, 293, 607
1438, 681, 635, 318, 682
1439, 320, 463, 560, 321
1440, 327, 754, 326, 563
1441, 721, 177, 421, 720
1442, 898, 596, 728, 897
1443, 529, 372, 371, 113
1444, 501, 754, 755, 327
1445, 755, 198, 501, 328
1446, 737, 898, 443, 890
1447, 915, 572, 316, 575
1448, 375, 373, 516, 350
1449, 876, 740, 881, 722
1450, 429, 505, 504, 558
1451, 922, 923, 848, 546
1452, 320, 158, 403, 678
1453, 376, 808, 822, 121
1454, 853, 478, 460, 383
1455, 935, 592, 610, 593
1456, 632, 704, 703, 717
1457, 242, 252, 350, 37
1458, 512, 561, 854, 616
1459, 699, 638, 648, 645
1460, 157, 321, 678, 690
1461, 252, 242, 350, 516
1462, 852, 851, 451, 854
1463, 842, 323, 690, 689
1464, 933, 478, 853, 383
1465, 456, 884, 447, 458
1466, 883, 903, 493, 910
1467, 534, 324, 535, 940
1468, 350, 527, 516, 375
1469, 494, 79, 788, 930
1470, 851, 895, 894, 893
1471, 879, 880, 906, 618
1472, 599, 860, 862, 595
1473, 133, 889, 387, 388
1474, 247, 32, 246, 515
1475, 81, 80, 497, 189
1476, 144, 430, 304, 305
1477, 436, 769, 360, 138
1478, 354, 304, 510, 834
1479, 647, 675, 624, 695
1480, 941, 863, 917, 918
1481, 313, 760, 871, 568
1482, 336, 570, 337, 728
1483, 497, 359, 190, 580
1484, 495, 357, 76, 434
1485, 908, 377, 376, 822
1486, 906, 874, 557, 907
1487, 357, 908, 376, 381
1488, 525, 803, 496, 261
1489, 770, 920, 139, 394
1490, 489, 187, 930, 494
1491, 661, 643, 701, 640
1492, 529, 113, 371, 271
1493, 885, 390, 884, 447
1494, 318, 453, 557, 558
1495, 906, 874, 481, 557
1496, 314, 704, 315, 632
1497, 314, 683, 315, 704
1498, 440, 933, 383, 478
1499, 352, 506, 505, 604
1500, 383, 933, 810, 827
1501, 444, 319, 559, 558
1502, 31, 518, 41, 348
1503, 429, 352, 505, 444
1504, 718, 663, 711, 662
1505, 704, 632, 703, 315
1506, 148, 831, 147, 54
1507, 683, 704, 703, 315
1508, 34, 234, 244, 245
1509, 918, 754, 326, 761
1510, 86, 499, 195, 491
1511, 279, 280, 818, 537
1512, 495, 434, 185, 579
1513, 768, 138, 436, 393
1514, 941, 863, 918, 862
1515, 411, 753, 941, 746
1516, 247, 517, 345, 515
1517, 754, 918, 326, 563
1518, 934, 896, 535, 816
1519, 564, 918, 563, 326
1520, 396, 224, 223, 510
1521, 609, 902, 341, 733
1522, 410, 863, 871, 464
1523, 896, 562, 537, 891
1524, 910, 727, 729, 897
1525, 312, 410, 863, 871
1526, 111, 427, 112, 272
1527, 863, 918, 871, 917
1528, 565, 362, 416, 417
1529, 727, 898, 897, 449
1530, 901, 465, 471, 870
1531, 75, 908, 74, 376
1532, 326, 568, 564, 918
1533, 427, 395, 371, 530
1534, 380, 851, 356, 451
1535, 895, 825, 894, 893
1536, 823, 598, 274, 531
1537, 901, 465, 414, 471
1538, 439, 893, 892, 380
1539, 163, 409, 871, 684
1540, 320, 698, 678, 321
1541, 561, 855, 445, 854
1542, 433, 512, 851, 238
1543, 595, 860, 612, 599
1544, 445, 561, 463, 855
1545, 761, 917, 871, 918
1546, 761, 871, 568, 918
1547, 427, 229, 530, 272
1548, 410, 409, 871, 163
1549, 690, 323, 645, 701
1550, 841, 324, 843, 839
1551, 562, 855, 854, 856
1552, 61, 227, 60, 395
1553, 721, 422, 178, 722
1554, 638, 699, 648, 715
1555, 909, 363, 904, 97
1556, 445, 512, 587, 561
1557, 562, 855, 856, 322
1558, 840, 839, 325, 592
1559, 157, 321, 403, 678
1560, 401, 402, 842, 478
1561, 429, 406, 558, 453
1562, 638, 650, 637, 715
1563, 313, 564, 568, 871
1564, 312, 410, 861, 863
1565, 312, 163, 685, 410
1566, 666, 622, 677, 649
1567, 524, 900, 525, 802
1568, 474, 423, 449, 898
1569, 896, 562, 891, 856
1570, 11, 622, 621, 676
1571, 436, 491, 360, 920
1572, 500, 86, 436, 499
1573, 769, 138, 139, 360
1574, 609, 904, 205, 503
1575, 885, 764, 135, 447
1576, 737, 898, 723, 443
1577, 905, 879, 877, 481
1578, 608, 342, 734, 574
1579, 209, 352, 506, 505
1580, 875, 869, 878, 482
1581, 853, 383, 460, 887
1582, 716, 663, 718, 712
1583, 626, 309, 713, 680
1584, 429, 99, 504, 208
1585, 825, 830, 892, 807
1586, 460, 887, 382, 470
1587, 279, 278, 535, 816
1588, 606, 820, 513, 282
1589, 462, 463, 855, 445
1590, 544, 595, 554, 861
1591, 323, 690, 689, 701
1592, 369, 793, 794, 106
1593, 865, 920, 394, 85
1594, 410, 405, 858, 456
1595, 165, 753, 411, 746
1596, 768, 769, 773, 436
1597, 875, 408, 161, 683
1598, 482, 916, 878, 448
1599, 302, 835, 509, 833
1600, 773, 860, 768, 436
1601, 869, 572, 915, 911
1602, 412, 166, 747, 167
1603, 423, 727, 183, 449
1604, 567, 602, 901, 332
1605, 83, 435, 857, 191
1606, 319, 159, 406, 404
1607, 468, 916, 419, 890
1608, 872, 483, 471, 443
1609, 720, 177, 421, 442
1610, 874, 318, 317, 407
1611, 468, 916, 482, 419
1612, 618, 907, 906, 557
1613, 903, 730, 339, 338
1614, 468, 916, 869, 482
1615, 463, 320, 404, 403
1616, 413, 760, 870, 901
1617, 463, 462, 855, 403
1618, 872, 483, 899, 471
1619, 758, 330, 565, 582
1620, 729, 576, 337, 338
1621, 864, 500, 860, 599
1622, 555, 872, 602, 597
1623, 870, 471, 487, 465
1624, 839, 459, 486, 480
1625, 727, 182, 426, 726
1626, 555, 572, 911, 569
1627, 898, 423, 443, 477
1628, 228, 395, 530, 547
1629, 852, 894, 891, 892
1630, 415, 941, 411, 753
1631, 725, 180, 882, 724
1632, 904, 204, 493, 903
1633, 889, 786, 763, 762
1634, 318, 319, 406, 558
1635, 873, 876, 469, 421
1636, 500, 599, 612, 860
1637, 643, 688, 307, 625
1638, 617, 499, 436, 773
1639, 193, 192, 925, 285
1640, 590, 857, 926, 498
1641, 450, 320, 463, 560
1642, 132, 386, 780, 131
1643, 687, 5, 642, 619
1644, 450, 320, 404, 463
1645, 243, 35, 233, 244
1646, 33, 246, 515, 514
1647, 450, 320, 559, 404
1648, 401, 841, 843, 480
1649, 307, 523, 844, 840
1650, 845, 452, 369, 849
1651, 610, 838, 524, 592
1652, 663, 668, 711, 662
1653, 931, 792, 800, 844
1654, 263, 373, 526, 516
1655, 526, 349, 577, 516
1656, 920, 769, 139, 360
1657, 77, 434, 579, 185
1658, 438, 879, 469, 481
1659, 353, 268, 115, 269
1660, 121, 808, 130, 381
1661, 280, 538, 818, 537
1662, 651, 626, 627, 713
1663, 402, 401, 842, 156
1664, 748, 749, 901, 414
1665, 868, 529, 372, 371
1666, 152, 399, 832, 151
1667, 218, 219, 299, 52
1668, 825, 819, 894, 818
1669, 125, 932, 380, 893
1670, 270, 529, 271, 113
1671, 836, 153, 141, 398
1672, 798, 849, 497, 588
1673, 395, 551, 294, 547
1674, 190, 81, 497, 189
1675, 441, 888, 923, 763
1676, 226, 305, 430, 585
1677, 924, 889, 928, 927
1678, 148, 831, 552, 300
1679, 163, 164, 685, 410
1680, 467, 411, 941, 917
1681, 638, 650, 715, 648
1682, 238, 433, 71, 356
1683, 606, 281, 819, 820
1684, 822, 377, 376, 122
1685, 764, 389, 135, 447
1686, 312, 705, 630, 629
1687, 367, 154, 475, 844
1688, 657, 714, 700, 656
1689, 727, 729, 897, 728
1690, 797, 254, 255, 519
1691, 479, 600, 559, 450
1692, 432, 347, 514, 68
1693, 906, 874, 873, 481
1694, 725, 742, 741, 883
1695, 341, 734, 733, 902
1696, 609, 902, 503, 341
1697, 176, 177, 720, 420
1698, 461, 927, 435, 928
1699, 203, 94, 493, 910
1700, 214, 507, 213, 47
1701, 846, 923, 847, 591
1702, 760, 334, 568, 333
1703, 850, 927, 924, 543
1704, 451, 439, 852, 488
1705, 854, 451, 852, 488
1706, 385, 936, 384, 459
1707, 476, 839, 486, 480
1708, 402, 478, 460, 853
1709, 450, 511, 559, 560
1710, 600, 511, 559, 450
1711, 743, 569, 911, 738
1712, 901, 566, 602, 597
1713, 390, 885, 135, 447
1714, 883, 726, 910, 425
1715, 94, 426, 910, 897
1716, 419, 176, 175, 719
1717, 875, 556, 575, 316
1718, 153, 836, 868, 398
1719, 703, 633, 634, 316
1720, 907, 875, 874, 317
1721, 721, 876, 422, 722
1722, 363, 97, 96, 904
1723, 903, 883, 493, 882
1724, 576, 729, 337, 596
1725, 910, 94, 95, 425
1726, 341, 573, 902, 503
1727, 474, 449, 437, 897
1728, 410, 405, 164, 858
1729, 411, 455, 941, 361
1730, 864, 455, 941, 862
1731, 630, 654, 705, 717
1732, 920, 769, 436, 773
1733, 729, 903, 730, 742
1734, 197, 864, 581, 196
1735, 501, 864, 581, 197
1736, 710, 654, 653, 670
1737, 133, 889, 763, 762
1738, 774, 595, 542, 289
1739, 133, 132, 387, 762
1740, 431, 273, 63, 110
1741, 895, 538, 606, 605
1742, 895, 538, 819, 606
1743, 426, 94, 910, 425
1744, 502, 597, 362, 898
1745, 869, 916, 878, 482
1746, 820, 938, 513, 829
1747, 550, 614, 508, 399
1748, 819, 825, 895, 824
1749, 896, 853, 322, 856
1750, 226, 60, 227, 585
1751, 940, 933, 841, 853
1752, 593, 325, 839, 592
1753, 155, 401, 843, 476
1754, 352, 209, 506, 43
1755, 395, 868, 371, 530
1756, 688, 325, 843, 689
1757, 935, 936, 839, 593
1758, 616, 512, 586, 851
1759, 670, 709, 673, 646
1760, 171, 91, 90, 751
1761, 900, 496, 579, 525
1762, 374, 589, 118, 428
1763, 354, 304, 430, 510
1764, 312, 863, 564, 871
1765, 231, 64, 526, 431
1766, 353, 508, 614, 399
1767, 603, 735, 343, 574
1768, 193, 192, 84, 925
1769, 928, 591, 845, 847
1770, 99, 877, 504, 207
1771, 583, 362, 417, 92
1772, 928, 888, 924, 847
1773, 234, 67, 244, 233
1774, 584, 879, 909, 877
1775, 457, 875, 878, 482
1776, 357, 837, 454, 434
1777, 208, 209, 505, 42
1778, 908, 826, 822, 823
1779, 413, 748, 168, 167
1780, 844, 368, 792, 845
1781, 322, 699, 690, 645
1782, 550, 399, 832, 866
1783, 915, 875, 878, 914
1784, 489, 496, 900, 930
1785, 448, 176, 878, 420
1786, 793, 105, 368, 792
1787, 397, 835, 833, 509
1788, 909, 584, 877, 206
1789, 915, 719, 744, 878
1790, 902, 904, 745, 733
1791, 385, 935, 459, 454
1792, 203, 94, 897, 202
1793, 171, 170, 417, 750
1794, 89, 198, 752, 492
1795, 565, 362, 597, 416
1796, 566, 901, 758, 565
1797, 296, 297, 832, 549
1798, 890, 418, 483, 443
1799, 529, 868, 530, 371
1800, 550, 399, 508, 151
1801, 895, 605, 606, 586
1802, 698, 637, 636, 708
1803, 698, 320, 636, 637
1804, 353, 528, 399, 614
1805, 929, 860, 862, 392
1806, 935, 837, 459, 454
1807, 837, 446, 459, 454
1808, 681, 319, 706, 679
1809, 486, 837, 446, 459
1810, 644, 702, 706, 707
1811, 319, 320, 636, 679
1812, 320, 698, 636, 679
1813, 854, 855, 488, 856
1814, 891, 896, 887, 830
1815, 462, 856, 470, 488
1816, 888, 923, 924, 847
1817, 928, 591, 849, 845
1818, 584, 905, 877, 504
1819, 905, 618, 906, 557
1820, 441, 405, 458, 848
1821, 556, 907, 618, 557
1822, 852, 439, 892, 887
1823, 876, 721, 421, 873
1824, 659, 658, 634, 702
1825, 234, 235, 514, 68
1826, 905, 879, 481, 906
1827, 879, 873, 481, 906
1828, 879, 876, 469, 873
1829, 683, 682, 161, 875
1830, 811, 933, 810, 128
1831, 406, 429, 558, 444
1832, 682, 635, 317, 634
1833, 703, 633, 658, 634
1834, 485, 873, 469, 442
1835, 378, 938, 829, 73
1836, 457, 485, 442, 912
1837, 615, 928, 927, 924
1838, 909, 363, 881, 904
1839, 450, 444, 404, 559
1840, 721, 876, 740, 739
1841, 319, 644, 318, 681
1842, 686, 4, 641, 3
1843, 686, 4, 619, 641
1844, 308, 154, 688, 844
1845, 308, 309, 680, 846
1846, 664, 626, 651, 712
1847, 308, 309, 626, 680
1848, 378, 379, 124, 805
1849, 11, 676, 26, 25
1850, 716, 661, 701, 665
1851, 727, 449, 426, 183
1852, 725, 424, 882, 180
1853, 676, 10, 621, 11
1854, 716, 665, 701, 648
1855, 661, 716, 701, 643
1856, 395, 427, 61, 228
1857, 660, 694, 674, 700
1858, 751, 91, 90, 492
1859, 830, 809, 887, 892
1860, 872, 890, 911, 899
1861, 236, 432, 235, 69
1862, 61, 395, 228, 227
1863, 693, 650, 691, 695
1864, 650, 715, 648, 695
1865, 911, 872, 569, 898
1866, 582, 757, 492, 91
1867, 659, 702, 634, 635
1868, 788, 101, 930, 79
1869, 324, 841, 937, 839
1870, 582, 756, 492, 757
1871, 115, 353, 269, 114
1872, 773, 287, 288, 541
1873, 243, 232, 233, 66
1874, 650, 693, 691, 642
1875, 905, 584, 557, 504
1876, 539, 241, 74, 240
1877, 386, 859, 387, 132
1878, 584, 909, 503, 206
1879, 672, 644, 707, 669
1880, 12, 622, 11, 25
1881, 620, 671, 700, 657
1882, 358, 789, 101, 930
1883, 545, 544, 311, 858
1884, 863, 917, 871, 464
1885, 303, 834, 833, 509
1886, 323, 842, 690, 322
1887, 902, 904, 881, 745
1888, 927, 191, 580, 498
1889, 904, 903, 493, 882
1890, 199, 582, 492, 200
1891, 910, 727, 726, 729
1892, 926, 780, 859, 857
1893, 210, 44, 348, 43
1894, 720, 719, 878, 744
1895, 369, 452, 359, 849
1896, 771, 782, 785, 925
1897, 324, 325, 689, 843
1898, 938, 72, 239, 73
1899, 904, 731, 741, 745
1900, 876, 740, 902, 881
1901, 192, 83, 84, 925
1902, 858, 456, 405, 884
1903, 573, 584, 909, 503
1904, 347, 33, 346, 514
1905, 236, 70, 587, 355
1906, 732, 736, 344, 915
1907, 676, 10, 11, 26
1908, 605, 562, 891, 537
1909, 378, 804, 829, 805
1910, 572, 732, 335, 344
1911, 347, 346, 432, 514
1912, 342, 735, 734, 574
1913, 346, 511, 432, 514
1914, 391, 865, 140, 394
1915, 770, 865, 920, 394
1916, 511, 346, 515, 514
1917, 782, 770, 920, 769
1918, 196, 361, 87, 88
1919, 863, 312, 564, 554
1920, 746, 754, 918, 761
1921, 864, 455, 862, 860
1922, 599, 500, 581, 864
1923, 411, 746, 941, 917
1924, 166, 165, 411, 746
1925, 553, 55, 221, 222
1926, 751, 752, 756, 492
1927, 198, 752, 492, 756
1928, 802, 838, 801, 524
1929, 89, 501, 415, 755
1930, 542, 774, 288, 601
1931, 801, 523, 259, 524
1932, 407, 160, 406, 318
1933, 544, 776, 290, 289
1934, 181, 424, 425, 883
1935, 802, 261, 525, 260
1936, 466, 597, 901, 872
1937, 773, 860, 774, 768
1938, 174, 423, 723, 183
1939, 363, 180, 179, 724
1940, 904, 206, 503, 909
1941, 765, 929, 136, 767
1942, 737, 419, 890, 418
1943, 71, 237, 433, 238
1944, 923, 779, 924, 607
1945, 725, 741, 882, 883
1946, 461, 927, 387, 435
1947, 859, 787, 762, 780
1948, 923, 591, 546, 607
1949, 545, 858, 310, 848
1950, 132, 859, 762, 780
1951, 352, 209, 43, 42
1952, 395, 836, 868, 547
1953, 901, 465, 413, 414
1954, 300, 219, 552, 52
1955, 737, 916, 719, 732
1956, 709, 673, 656, 717
1957, 70, 433, 587, 355
1958, 28, 6, 21, 20
1959, 219, 53, 552, 52
1960, 773, 860, 436, 617
1961, 773, 540, 772, 287
1962, 545, 777, 290, 921
1963, 923, 309, 546, 591
1964, 834, 396, 833, 509
1965, 907, 873, 880, 906
1966, 317, 682, 634, 316
1967, 445, 512, 433, 587
1968, 721, 720, 873, 739
1969, 79, 108, 80, 795
1970, 272, 427, 112, 530
1971, 687, 693, 642, 691
1972, 377, 240, 74, 73
1973, 468, 483, 487, 899
1974, 157, 321, 402, 403
1975, 608, 611, 880, 618
1976, 803, 802, 900, 789
1977, 802, 790, 900, 789
1978, 366, 446, 838, 365
1979, 597, 477, 872, 466
1980, 346, 32, 345, 515
1981, 910, 727, 426, 726
1982, 53, 148, 552, 52
1983, 366, 790, 103, 365
1984, 300, 52, 552, 148
1985, 857, 926, 498, 927
1986, 639, 665, 701, 640
1987, 625, 664, 663, 712
1988, 82, 191, 190, 580
1989, 931, 792, 791, 800
1990, 191, 435, 927, 580
1991, 353, 268, 269, 578
1992, 353, 578, 269, 528
1993, 814, 936, 533, 937
1994, 934, 815, 939, 827
1995, 440, 933, 128, 383
1996, 815, 534, 277, 278
1997, 644, 672, 706, 636
1998, 735, 914, 744, 913
1999, 385, 936, 812, 384
2000, 291, 545, 546, 922
2001, 922, 291, 778, 546
2002, 595, 776, 929, 544
2003, 575, 875, 914, 913
2004, 922, 545, 848, 921
2005, 814, 936, 812, 935
2006, 191, 435, 857, 927
2007, 724, 881, 722, 179
2008, 703, 683, 315, 316
2009, 151, 399, 508, 51
2010, 306, 143, 305, 585
2011, 396, 223, 222, 509
2012, 775, 543, 779, 293
2013, 148, 52, 149, 300
2014, 373, 109, 526, 431
2015, 4, 686, 29, 30
2016, 191, 857, 498, 927
2017, 929, 544, 921, 858
2018, 198, 329, 328, 756
2019, 609, 902, 904, 503
2020, 314, 683, 704, 684
2021, 615, 928, 849, 927
2022, 413, 760, 748, 747
2023, 901, 466, 414, 416
2024, 854, 488, 852, 856
2025, 775, 850, 779, 543
2026, 820, 539, 821, 829
2027, 839, 841, 480, 843
2028, 850, 543, 924, 779
2029, 471, 901, 466, 414
2030, 229, 427, 530, 228
2031, 720, 912, 878, 420
2032, 911, 335, 569, 572
2033, 729, 903, 338, 730
2034, 572, 732, 344, 915
2035, 471, 901, 872, 466
2036, 143, 430, 305, 585
2037, 555, 872, 870, 602
2038, 506, 479, 604, 352
2039, 504, 364, 481, 877
2040, 314, 555, 870, 602
2041, 396, 397, 833, 509
2042, 838, 476, 486, 366
2043, 845, 452, 368, 369
2044, 845, 452, 849, 928
2045, 545, 858, 311, 310
2046, 126, 380, 807, 125
2047, 617, 860, 601, 773
2048, 938, 820, 895, 824
2049, 845, 792, 800, 799
2050, 451, 356, 433, 851
2051, 840, 155, 843, 476
2052, 765, 885, 390, 929
2053, 885, 929, 921, 884
2054, 844, 368, 367, 792
2055, 929, 858, 921, 884
2056, 191, 435, 82, 83
2057, 670, 709, 646, 696
2058, 308, 154, 680, 688
2059, 543, 926, 498, 590
2060, 366, 790, 791, 103
2061, 830, 894, 825, 892
2062, 792, 845, 800, 844
2063, 844, 368, 475, 367
2064, 754, 941, 918, 563
2065, 847, 475, 472, 441
2066, 896, 323, 853, 934
2067, 501, 864, 197, 415
2068, 312, 163, 684, 685
2069, 758, 901, 416, 565
2070, 537, 896, 816, 535
2071, 484, 473, 410, 861
2072, 863, 467, 917, 464
2073, 842, 324, 940, 323
2074, 891, 896, 830, 816
2075, 705, 654, 630, 629
2076, 726, 742, 910, 729
2077, 285, 192, 925, 590
2078, 633, 632, 703, 657
2079, 617, 500, 860, 436
2080, 474, 898, 449, 897
2081, 864, 455, 361, 941
2082, 324, 842, 689, 323
2083, 308, 688, 307, 844
2084, 196, 361, 500, 87
2085, 682, 635, 318, 317
2086, 830, 896, 827, 816
2087, 462, 855, 488, 445
2088, 864, 455, 860, 361
2089, 752, 89, 90, 172
2090, 941, 599, 918, 563
2091, 713, 705, 685, 311
2092, 917, 746, 166, 411
2093, 665, 716, 668, 648
2094, 927, 926, 498, 543
2095, 409, 413, 464, 871
2096, 596, 576, 897, 502
2097, 872, 555, 870, 899
2098, 872, 890, 898, 911
2099, 324, 534, 937, 940
2100, 830, 894, 818, 825
2101, 380, 125, 893, 807
2102, 379, 938, 805, 378
2103, 235, 432, 514, 68
2104, 881, 876, 909, 902
2105, 394, 920, 360, 85
2106, 525, 803, 900, 496
2107, 894, 537, 605, 891
2108, 877, 438, 481, 879
2109, 895, 851, 932, 893
2110, 873, 879, 481, 469
2111, 859, 889, 927, 387
2112, 683, 314, 315, 870
2113, 938, 606, 820, 513
2114, 698, 699, 678, 321
2115, 698, 320, 678, 679
2116, 820, 606, 895, 819
2117, 667, 715, 637, 650
2118, 562, 605, 891, 852
2119, 501, 864, 563, 581
2120, 845, 522, 800, 844
2121, 384, 841, 933, 440
2122, 607, 924, 615, 543
2123, 786, 850, 924, 779
2124, 792, 793, 845, 368
2125, 927, 889, 850, 924
2126, 308, 154, 846, 680
2127, 501, 754, 563, 864
2128, 809, 127, 382, 126
2129, 460, 383, 382, 887
2130, 936, 533, 593, 935
2131, 847, 452, 928, 472
2132, 380, 851, 932, 356
2133, 809, 830, 807, 892
2134, 380, 851, 893, 932
2135, 554, 544, 861, 311
2136, 928, 889, 888, 461
2137, 928, 461, 888, 472
2138, 507, 374, 527, 351
2139, 932, 825, 893, 806
2140, 496, 803, 900, 930
2141, 683, 870, 315, 869
2142, 636, 698, 706, 679
2143, 615, 928, 591, 849
2144, 803, 253, 796, 930
2145, 253, 496, 930, 803
2146, 253, 187, 494, 930
2147, 703, 714, 658, 657
2148, 758, 749, 750, 416
2149, 704, 314, 631, 632
2150, 704, 314, 313, 631
2151, 424, 883, 882, 493
2152, 735, 342, 343, 574
2153, 599, 864, 563, 941
2154, 873, 907, 880, 913
2155, 603, 611, 913, 574
2156, 373, 516, 350, 349
2157, 453, 407, 406, 318
2158, 915, 736, 914, 744
2159, 447, 389, 458, 886
2160, 864, 754, 563, 941
2161, 595, 774, 542, 860
2162, 941, 746, 918, 917
2163, 165, 753, 415, 411
2164, 412, 166, 411, 917
2165, 166, 412, 747, 917
2166, 601, 617, 612, 860
2167, 524, 900, 579, 525
2168, 941, 754, 918, 746
2169, 79, 101, 100, 788
2170, 357, 837, 532, 454
2171, 814, 828, 811, 936
2172, 747, 166, 917, 746
2173, 313, 409, 413, 870
2174, 890, 468, 899, 483
2175, 703, 658, 702, 634
2176, 743, 569, 570, 898
2177, 437, 202, 93, 502
2178, 738, 336, 569, 335
2179, 672, 697, 667, 619
2180, 313, 705, 630, 312
2181, 471, 899, 487, 483
2182, 778, 922, 783, 777
2183, 727, 898, 728, 897
2184, 192, 857, 83, 925
2185, 933, 828, 939, 937
2186, 842, 324, 689, 843
2187, 253, 494, 796, 930
2188, 24, 622, 677, 623
2189, 823, 598, 817, 274
2190, 542, 601, 612, 860
2191, 358, 102, 101, 789
2192, 863, 312, 554, 861
2193, 311, 858, 685, 310
2194, 863, 410, 861, 484
2195, 776, 784, 921, 777
2196, 760, 334, 761, 568
2197, 704, 705, 630, 313
2198, 101, 789, 788, 930
2199, 539, 826, 241, 536
2200, 78, 489, 930, 494
2201, 401, 440, 478, 841
2202, 276, 275, 532, 813
2203, 534, 324, 937, 593
2204, 187, 496, 930, 253
2205, 869, 555, 911, 899
2206, 478, 933, 853, 841
2207, 440, 933, 478, 841
2208, 677, 622, 696, 649
2209, 707, 635, 659, 669
2210, 707, 635, 702, 659
2211, 698, 715, 637, 708
2212, 663, 716, 711, 668
2213, 710, 649, 696, 670
2214, 681, 644, 702, 706
2215, 644, 681, 702, 635
2216, 622, 677, 696, 676
2217, 471, 899, 870, 487
2218, 644, 318, 681, 635
2219, 6, 28, 687, 20
2220, 911, 872, 555, 569
2221, 611, 608, 880, 574
2222, 663, 664, 718, 712
2223, 28, 5, 687, 29
2224, 651, 666, 718, 710
2225, 519, 80, 490, 189
2226, 667, 715, 708, 637
2227, 710, 666, 652, 651
2228, 709, 710, 696, 670
2229, 654, 710, 709, 670
2230, 697, 686, 619, 641
2231, 863, 484, 861, 862
2232, 319, 636, 706, 679
2233, 682, 703, 634, 316
2234, 880, 608, 734, 574
2235, 737, 916, 419, 719
2236, 735, 880, 734, 574
2237, 423, 727, 723, 183
2238, 922, 291, 777, 778
2239, 907, 611, 880, 913
2240, 551, 60, 227, 395
2241, 703, 657, 632, 717
2242, 882, 363, 96, 904
2243, 69, 235, 68, 432
2244, 424, 493, 882, 96
2245, 729, 596, 728, 337
2246, 457, 875, 912, 878
2247, 880, 573, 734, 608
2248, 468, 869, 487, 482
2249, 176, 720, 878, 420
2250, 424, 363, 96, 882
2251, 597, 477, 362, 898
2252, 424, 181, 725, 883
2253, 741, 725, 882, 724
2254, 883, 424, 425, 95
2255, 89, 752, 90, 492
2256, 203, 576, 910, 338
2257, 742, 726, 910, 883
2258, 729, 576, 338, 910
2259, 752, 753, 415, 173
2260, 764, 886, 389, 447
2261, 657, 632, 717, 656
2262, 417, 171, 751, 91
2263, 313, 564, 871, 312
2264, 599, 554, 862, 564
2265, 230, 231, 262, 431
2266, 133, 889, 388, 763
2267, 169, 749, 414, 416
2268, 872, 890, 443, 898
2269, 577, 242, 349, 36
2270, 765, 885, 929, 784
2271, 565, 362, 583, 597
2272, 526, 349, 64, 577
2273, 4, 686, 619, 29
2274, 845, 846, 847, 591
2275, 265, 589, 118, 374
2276, 900, 77, 358, 434
2277, 646, 709, 673, 656
2278, 526, 349, 373, 64
2279, 588, 849, 497, 580
2280, 564, 918, 568, 871
2281, 660, 671, 707, 700
2282, 353, 50, 49, 216
2283, 578, 50, 216, 217
2284, 910, 203, 94, 897
2285, 474, 502, 897, 437
2286, 389, 441, 458, 886
2287, 782, 771, 772, 919
2288, 461, 927, 889, 387
2289, 386, 859, 132, 780
2290, 922, 848, 886, 921
2291, 4, 5, 29, 619
2292, 837, 434, 579, 900
2293, 849, 370, 798, 497
2294, 5, 687, 29, 619
2295, 576, 202, 897, 502
2296, 496, 187, 930, 489
2297, 256, 798, 255, 520
2298, 840, 154, 155, 367
2299, 325, 324, 593, 839
2300, 901, 566, 597, 565
2301, 840, 154, 688, 155
2302, 606, 281, 538, 819
2303, 715, 716, 648, 695
2304, 840, 367, 155, 476
2305, 320, 158, 404, 403
2306, 894, 852, 893, 892
2307, 686, 697, 619, 29
2308, 380, 356, 932, 379
2309, 820, 938, 829, 824
2310, 512, 586, 851, 238
2311, 692, 620, 646, 8
2312, 512, 854, 851, 616
2313, 697, 687, 619, 29
2314, 378, 124, 123, 805
2315, 932, 124, 125, 379
2316, 840, 367, 476, 931
2317, 900, 77, 434, 579
2318, 606, 281, 820, 282
2319, 903, 571, 204, 339
2320, 826, 539, 821, 536
2321, 856, 439, 470, 488
2322, 817, 283, 536, 821
2323, 569, 597, 872, 555
2324, 593, 324, 937, 839
2325, 665, 661, 701, 640
2326, 864, 501, 755, 415
2327, 416, 597, 466, 362
2328, 277, 937, 814, 533
2329, 279, 537, 816, 535
2330, 828, 933, 810, 811
2331, 283, 539, 536, 821
2332, 699, 698, 637, 321
2333, 786, 923, 778, 779
2334, 159, 319, 679, 404
2335, 583, 362, 502, 597
2336, 625, 643, 712, 663
2337, 24, 622, 12, 25
2338, 787, 926, 850, 775
2339, 779, 292, 293, 607
2340, 318, 160, 406, 681
2341, 415, 941, 361, 411
2342, 761, 871, 760, 568
2343, 554, 312, 311, 861
2344, 595, 554, 861, 862
2345, 690, 842, 689, 156
2346, 358, 434, 365, 900
2347, 907, 873, 874, 912
2348, 682, 407, 317, 318
2349, 864, 754, 753, 755
2350, 93, 202, 201, 502
2351, 437, 202, 94, 93
2352, 407, 408, 161, 875
2353, 923, 292, 607, 546
2354, 923, 292, 779, 607
2355, 401, 842, 843, 841
2356, 885, 929, 884, 390
2357, 776, 929, 921, 784
2358, 312, 163, 871, 684
2359, 350, 527, 375, 351
2360, 762, 850, 786, 787
2361, 784, 922, 921, 777
2362, 825, 807, 893, 806
2363, 350, 527, 351, 252
2364, 395, 836, 294, 141
2365, 12, 13, 623, 24
2366, 922, 784, 783, 777
2367, 324, 323, 689, 701
2368, 319, 318, 406, 681
2369, 50, 353, 578, 216
2370, 867, 353, 114, 269
2371, 923, 292, 778, 779
2372, 449, 727, 426, 897
2373, 291, 292, 778, 546
2374, 402, 462, 403, 855
2375, 493, 424, 95, 96
2376, 437, 202, 897, 94
2377, 384, 936, 480, 459
2378, 736, 735, 914, 744
2379, 16, 15, 674, 1
2380, 584, 573, 909, 879
2381, 478, 402, 842, 853
2382, 731, 340, 733, 609
2383, 740, 745, 902, 881
2384, 933, 384, 128, 811
2385, 846, 154, 475, 405
2386, 703, 682, 634, 702
2387, 448, 719, 176, 419
2388, 325, 324, 701, 640
2389, 688, 325, 701, 643
2390, 405, 884, 458, 848
2391, 689, 401, 842, 843
2392, 846, 441, 848, 405
2393, 191, 435, 580, 82
2394, 928, 452, 461, 472
2395, 500, 617, 860, 612
2396, 914, 344, 915, 575
2397, 874, 318, 557, 317
2398, 814, 594, 533, 935
2399, 159, 160, 681, 406
2400, 308, 626, 712, 680
2401, 908, 808, 813, 823
2402, 324, 639, 701, 640
2403, 688, 308, 712, 680
2404, 935, 592, 838, 610
2405, 655, 631, 656, 717
2406, 704, 632, 631, 717
2407, 501, 754, 864, 755
2408, 24, 622, 25, 677
2409, 926, 781, 925, 590
2410, 453, 874, 557, 481
2411, 82, 190, 359, 580
2412, 841, 324, 937, 940
2413, 920, 770, 139, 769
2414, 773, 288, 601, 541
2415, 499, 540, 773, 541
2416, 846, 309, 923, 591
2417, 435, 580, 849, 927
2418, 284, 926, 775, 543
2419, 881, 724, 722, 745
2420, 284, 926, 781, 775
2421, 321, 320, 403, 678
2422, 660, 694, 641, 15
2423, 672, 694, 697, 641
2424, 81, 497, 370, 359
2425, 107, 108, 794, 370
2426, 133, 763, 388, 134
2427, 284, 926, 590, 781
2428, 248, 518, 41, 31
2429, 319, 159, 681, 406
2430, 487, 869, 408, 482
2431, 627, 713, 652, 651
2432, 710, 718, 651, 712
2433, 719, 736, 915, 744
2434, 720, 912, 739, 744
2435, 933, 384, 440, 128
2436, 352, 209, 42, 505
2437, 248, 518, 249, 41
2438, 914, 915, 744, 878
2439, 416, 597, 901, 466
2440, 542, 774, 601, 860
2441, 487, 869, 870, 408
2442, 422, 876, 881, 722
2443, 424, 883, 493, 95
2444, 713, 710, 651, 712
2445, 357, 837, 495, 532
2446, 842, 401, 478, 841
2447, 876, 880, 740, 739
2448, 710, 713, 651, 652
2449, 686, 4, 3, 30
2450, 259, 523, 801, 258
2451, 880, 735, 913, 574
2452, 284, 926, 543, 590
2453, 539, 826, 74, 241
2454, 767, 860, 392, 393
2455, 748, 413, 747, 167
2456, 582, 756, 199, 492
2457, 582, 756, 329, 199
2458, 199, 198, 492, 756
2459, 198, 199, 329, 756
2460, 929, 774, 767, 776
2461, 136, 929, 392, 767
2462, 111, 273, 63, 62
2463, 352, 506, 345, 348
2464, 875, 907, 912, 913
2465, 273, 229, 63, 62
2466, 714, 671, 658, 657
2467, 862, 455, 392, 860
2468, 47, 589, 428, 266
2469, 589, 507, 47, 428
2470, 507, 589, 47, 214
2471, 510, 58, 430, 354
2472, 354, 304, 144, 430
2473, 441, 846, 848, 923
2474, 767, 860, 929, 392
2475, 137, 393, 767, 392
2476, 450, 511, 355, 432
2477, 62, 272, 111, 273
2478, 714, 657, 717, 656
2479, 582, 417, 757, 91
2480, 666, 622, 623, 677
2481, 229, 427, 62, 272
2482, 81, 82, 190, 359
2483, 749, 901, 414, 416
2484, 287, 540, 541, 773
2485, 647, 668, 711, 695
2486, 369, 793, 106, 368
2487, 775, 787, 779, 850
2488, 308, 309, 846, 591
2489, 849, 370, 369, 798
2490, 781, 285, 590, 284
2491, 193, 865, 919, 925
2492, 915, 572, 575, 344
2493, 865, 782, 920, 919
2494, 545, 777, 291, 290
2495, 206, 877, 98, 207
2496, 764, 885, 784, 886
2497, 22, 15, 3, 30
2498, 427, 111, 62, 272
2499, 758, 417, 582, 565
2500, 759, 331, 332, 566
2501, 752, 198, 755, 756
2502, 751, 752, 90, 172
2503, 621, 670, 646, 696
2504, 709, 692, 646, 696
2505, 551, 142, 294, 306
2506, 660, 694, 15, 674
2507, 171, 417, 751, 750
2508, 757, 417, 751, 91
2509, 247, 517, 248, 31
2510, 39, 250, 46, 40
2511, 247, 32, 345, 31
2512, 463, 320, 403, 321
2513, 130, 385, 381, 812
2514, 709, 714, 717, 656
2515, 603, 575, 914, 913
2516, 302, 835, 553, 509
2517, 793, 792, 845, 799
2518, 796, 494, 788, 930
2519, 148, 54, 53, 552
2520, 813, 935, 812, 381
2521, 54, 220, 53, 552
2522, 849, 370, 359, 369
2523, 298, 550, 508, 151
2524, 243, 242, 577, 36
2525, 577, 231, 64, 526
2526, 67, 35, 244, 233
2527, 252, 38, 350, 37
2528, 242, 37, 349, 36
2529, 808, 130, 381, 812
2530, 938, 606, 895, 820
2531, 257, 522, 800, 799
2532, 410, 311, 858, 685
2533, 103, 790, 102, 365
2534, 314, 704, 313, 684
2535, 687, 642, 20, 691
2536, 495, 434, 76, 185
2537, 773, 860, 601, 774
2538, 521, 257, 256, 799
2539, 870, 314, 313, 684
2540, 830, 809, 827, 887
2541, 163, 162, 409, 684
2542, 15, 660, 674, 1
2543, 933, 383, 810, 128
2544, 162, 870, 409, 684
2545, 714, 703, 658, 702
2546, 99, 364, 429, 504
2547, 938, 378, 829, 805
2548, 534, 940, 939, 937
2549, 808, 813, 812, 381
2550, 936, 841, 839, 937
2551, 668, 647, 711, 662
2552, 761, 871, 747, 760
2553, 668, 716, 711, 695
2554, 675, 677, 711, 623
2555, 567, 760, 568, 333
2556, 516, 120, 375, 264
2557, 385, 935, 454, 381
2558, 428, 118, 117, 266
2559, 567, 760, 313, 568
2560, 375, 264, 120, 119
2561, 825, 895, 932, 893
2562, 119, 527, 264, 265
2563, 935, 385, 812, 381
2564, 137, 136, 392, 767
2565, 477, 872, 471, 443
2566, 671, 660, 620, 700
2567, 865, 770, 140, 394
2568, 908, 377, 74, 376
2569, 522, 845, 800, 799
2570, 769, 920, 436, 360
2571, 427, 229, 62, 228
2572, 864, 862, 599, 860
2573, 272, 112, 271, 530
2574, 929, 860, 595, 862
2575, 554, 863, 862, 564
2576, 866, 372, 399, 400
2577, 52, 299, 149, 300
2578, 862, 863, 918, 564
2579, 845, 522, 521, 799
2580, 710, 705, 654, 717
2581, 157, 321, 690, 402
2582, 367, 366, 476, 931
2583, 312, 705, 685, 684
2584, 840, 367, 931, 844
2585, 790, 802, 900, 838
2586, 659, 671, 658, 714
2587, 325, 324, 689, 701
2588, 683, 408, 869, 875
2589, 340, 341, 733, 609
2590, 98, 909, 877, 206
2591, 758, 417, 757, 582
2592, 721, 177, 178, 421
2593, 424, 181, 180, 725
2594, 422, 721, 178, 421
2595, 824, 932, 805, 806
2596, 366, 790, 838, 791
2597, 208, 429, 505, 504
2598, 847, 475, 846, 845
2599, 102, 900, 789, 358
2600, 446, 837, 365, 434
2601, 881, 363, 179, 724
2602, 422, 881, 438, 179
2603, 881, 363, 438, 179
2604, 710, 654, 709, 717
2605, 666, 664, 718, 662
2606, 705, 704, 630, 717
2607, 88, 864, 197, 196
2608, 588, 798, 256, 520
2609, 520, 797, 519, 497
2610, 790, 900, 365, 838
2611, 825, 807, 892, 893
2612, 385, 936, 935, 812
2613, 240, 938, 239, 73
2614, 894, 537, 538, 605
2615, 582, 91, 492, 200
2616, 362, 93, 92, 201
2617, 44, 518, 41, 211
2618, 673, 655, 656, 717
2619, 583, 362, 92, 201
2620, 494, 78, 79, 930
2621, 891, 852, 887, 856
2622, 856, 439, 887, 470
2623, 505, 604, 558, 444
2624, 598, 274, 536, 817
2625, 439, 382, 887, 470
2626, 395, 868, 398, 371
2627, 109, 110, 262, 431
2628, 277, 937, 815, 814
2629, 473, 456, 410, 861
2630, 929, 456, 861, 858
2631, 231, 577, 64, 65
2632, 55, 397, 396, 222
2633, 34, 347, 234, 245
2634, 813, 908, 531, 532
2635, 72, 938, 379, 73
2636, 929, 473, 861, 456
2637, 677, 718, 711, 662
2638, 34, 67, 234, 347
2639, 346, 33, 515, 514
2640, 412, 871, 917, 464
2641, 54, 831, 147, 553
2642, 567, 760, 332, 901
2643, 347, 34, 33, 245
2644, 761, 917, 747, 871
2645, 314, 567, 602, 870
2646, 397, 54, 147, 553
2647, 303, 510, 304, 834
2648, 901, 760, 748, 413
2649, 553, 55, 397, 54
2650, 47, 266, 428, 117
2651, 380, 379, 932, 125
2652, 243, 232, 36, 577
2653, 33, 246, 514, 245
2654, 241, 908, 184, 598
2655, 235, 511, 514, 432
2656, 258, 523, 801, 800
2657, 870, 760, 567, 901
2658, 283, 539, 821, 282
2659, 448, 719, 878, 176
2660, 717, 654, 655, 630
2661, 615, 588, 580, 849
2662, 860, 768, 393, 767
2663, 922, 923, 886, 848
2664, 289, 774, 288, 542
2665, 134, 886, 763, 441
2666, 476, 839, 480, 843
2667, 266, 589, 214, 47
2668, 551, 395, 294, 142
2669, 654, 709, 717, 673
2670, 655, 654, 717, 673
2671, 837, 446, 365, 838
2672, 176, 720, 719, 878
2673, 448, 719, 916, 878
2674, 704, 631, 630, 717
2675, 407, 485, 874, 453
2676, 556, 907, 317, 875
2677, 631, 655, 630, 717
2678, 631, 632, 656, 717
2679, 907, 874, 557, 317
2680, 908, 826, 823, 817
2681, 638, 699, 321, 322
2682, 285, 919, 193, 286
2683, 561, 322, 321, 855
2684, 692, 621, 646, 696
2685, 761, 917, 746, 747
2686, 621, 16, 676, 692
2687, 891, 830, 887, 892
2688, 911, 335, 738, 569
2689, 731, 903, 730, 339
2690, 731, 340, 571, 339
2691, 852, 605, 891, 894
2692, 56, 55, 396, 222
2693, 609, 902, 733, 904
2694, 894, 537, 818, 538
2695, 350, 527, 252, 516
2696, 838, 802, 801, 790
2697, 252, 350, 38, 351
2698, 375, 264, 527, 516
2699, 823, 598, 908, 817
2700, 817, 274, 536, 283
2701, 753, 752, 415, 755
2702, 553, 55, 54, 221
2703, 900, 803, 789, 930
2704, 412, 871, 747, 917
2705, 603, 556, 575, 913
2706, 595, 542, 612, 860
2707, 898, 570, 728, 596
2708, 232, 243, 36, 66
2709, 791, 838, 801, 790
2710, 727, 898, 723, 728
2711, 936, 935, 839, 459
2712, 446, 366, 838, 486
2713, 476, 401, 843, 480
2714, 842, 324, 843, 841
2715, 840, 839, 838, 476
2716, 430, 510, 304, 305
2717, 898, 743, 723, 728
2718, 721, 876, 739, 873
2719, 786, 850, 889, 924
2720, 664, 663, 718, 662
2721, 831, 301, 552, 300
2722, 763, 764, 783, 886
2723, 838, 931, 840, 476
2724, 220, 553, 54, 221
2725, 182, 727, 426, 183
2726, 556, 611, 913, 603
2727, 456, 858, 410, 861
2728, 929, 473, 484, 861
2729, 743, 569, 738, 570
2730, 313, 409, 871, 413
2731, 929, 595, 861, 862
2732, 477, 872, 443, 898
2733, 597, 477, 466, 362
2734, 554, 863, 861, 862
2735, 484, 410, 467, 863
2736, 855, 562, 561, 322
2737, 842, 323, 853, 322
2738, 413, 760, 747, 871
2739, 323, 896, 853, 322
2740, 323, 639, 645, 701
2741, 507, 374, 351, 428
2742, 699, 638, 645, 322
2743, 761, 917, 918, 746
2744, 768, 393, 436, 860
2745, 748, 749, 759, 901
2746, 907, 873, 912, 913
