*Heading
Kurbel, lineare Tetraeder, feines Netz
*Node
1, 73.846154, 0, -290.76923
2, 73.846154, 0, 290.76923
3, 1200, 0, 150
4, 1200, 0, -150
5, 96, 0, -2.094146e-14
6, -96, 0, 1.4328368e-14
7, 690, 0, -1.4695762e-14
8, 450, 0, 2.9391523e-14
9, 990, 0, -1.1021821e-14
10, 810, 0, 2.2043642e-14
11, 30, 0, -228
12, -30, 0, -228
13, -140.00714, 0, -182.43355
14, -182.43355, 0, -140.00714
15, -228, 0, -30
16, -228, 0, 30
17, -182.43355, 0, 140.00714
18, -140.00714, 0, 182.43355
19, -30, 0, 228
20, 30, 0, 228
21, 1200, 0, -60
22, 1140, 0, -60
23, 1200, 0, 60
24, 1140, 0, 60
25, 73.846154, 60, 290.76923
26, 73.846154, 60, -290.76923
27, 1200, 60, -150
28, 1200, 60, 150
29, 150, 60, 1.8369702e-14
30, -150, 60, -3.6739404e-14
31, 690, 60, -1.4695762e-14
32, 450, 60, 2.9391523e-14
33, 990, 60, -1.1021821e-14
34, 810, 60, 2.2043642e-14
35, 30, 60, -228
36, -30, 60, -228
37, -140.00714, 60, -182.43355
38, -182.43355, 60, -140.00714
39, -228, 60, -30
40, -228, 60, 30
41, -182.43355, 60, 140.00714
42, -140.00714, 60, 182.43355
43, -30, 60, 228
44, 30, 60, 228
45, 1200, 60, -60
46, 1140, 60, -60
47, 1140, 60, 60
48, 1200, 60, 60
49, 20, 300, -148.66069
50, 20, 360, -148.66069
51, 150, 360, 1.8369702e-14
52, -150, 360, -1.8369702e-14
53, -20, 360, -148.66069
54, -20, 300, -148.66069
55, 20, 300, -93.893557
56, -20, 300, -93.893557
57, -20, 300, 148.66069
58, 20, 300, 148.66069
59, -20, 300, 93.893557
60, 20, 300, 93.893557
61, 20, 360, 148.66069
62, 20, 360, 93.893557
63, 20, 360, -93.893557
64, -20, 360, -93.893557
65, -96, 360, 0
66, -20, 360, 93.893557
67, -20, 360, 148.66069
68, 96, 360, -2.094146e-14
69, 37.397526, 0, -297.65992
70, 4.7437565, 0, -299.96249
71, -23.615886, 0, -299.06904
72, -52.839264, 0, -295.31003
73, -95.114318, 0, -284.52288
74, -136.35099, 0, -267.22352
75, -167.38212, 0, -248.96431
76, -193.51124, 0, -229.24528
77, -216.58237, 0, -207.58631
78, -237.91031, 0, -182.75307
79, -256.4056, 0, -155.74391
80, -276.28424, 0, -116.90601
81, -290.59251, 0, -74.538522
82, -297.70669, 0, -37.0233
83, -299.95034, 0, -5.4582178
84, -298.85658, 0, 26.167595
85, -292.87746, 0, 64.983022
86, -278.36551, 0, 111.85993
87, -255.26531, 0, 157.6059
88, -236.57394, 0, 184.47973
89, -218.83565, 0, 205.20955
90, -195.17455, 0, 227.83085
91, -167.38212, 0, 248.96431
92, -127.52757, 0, 271.54506
93, -74.17315, 0, 290.68599
94, -31.225612, 0, 298.37051
95, 0.37713894, 0, 299.99976
96, 31.975694, 0, 298.29106
97, 121.33166, 0, 278.97935
98, 183.35739, 0, 264.38762
99, 275.64755, 0, 244.353
100, 394.07953, 0, 221.54386
101, 499.5753, 0, 203.93483
102, 590.79043, 0, 190.74276
103, 677.73089, 0, 179.90814
104, 773.92526, 0, 169.88361
105, 849.8854, 0, 163.41642
106, 919.12823, 0, 158.62988
107, 995.25573, 0, 154.58374
108, 1072.5775, 0, 151.77482
109, 1134.0071, 0, 150.47599
110, 1265.9909, 0, 134.70414
111, 1321.6289, 0, 87.786113
112, 1346.9783, 0, 29.956497
113, 1347.6847, 0, -26.253459
114, 1323.7966, 0, -84.701843
115, 1265.1432, 0, -135.11611
116, 1129.4562, 0, -150.5439
117, 1064.6158, 0, -152.00359
118, 989.57235, 0, -154.84188
119, 919.12823, 0, -158.62988
120, 858.96218, 0, -162.72883
121, 786.38877, 0, -168.735
122, 686.77519, 0, -178.87799
123, 591.91816, 0, -190.59139
124, 497.32652, 0, -204.2838
125, 403.04156, 0, -219.94925
126, 287.9092, 0, -241.84092
127, 191.12471, 0, -262.62444
128, 123.54333, 0, -278.44335
129, 83.088128, 0, 48.087036
130, 47.82577, 0, 83.238787
131, -0.3015924, 0, 95.999526
132, -48.087036, 0, 83.088128
133, -83.238787, 0, 47.82577
134, -83.088128, 0, -48.087036
135, -48.087036, 0, -83.088128
136, -0.3015924, 0, -95.999526
137, 47.82577, 0, -83.238787
138, 83.238787, 0, -47.82577
139, 673.86016, 0, 60.108795
140, 630.1088, 0, 103.86016
141, 570, 0, 120
142, 510.21779, 0, 104.04848
143, 465.95152, 0, 59.782213
144, 466.13984, 0, -60.108795
145, 510.21779, 0, -104.04848
146, 570.37699, 0, -119.99941
147, 630.1088, 0, -103.86016
148, 674.04848, 0, -59.782213
149, 977.89512, 0, 45.081596
150, 944.83666, 0, 78.036363
151, 899.71726, 0, 89.999556
152, 854.9184, 0, 77.89512
153, 821.96364, 0, 44.836659
154, 821.96364, 0, -44.836659
155, 854.42987, 0, -77.610328
156, 899.15178, 0, -89.996003
157, 945.81373, 0, -77.466782
158, 978.17684, 0, -44.59128
159, 26.058945, 0, -213.13624
160, 15.35229, 0, -202.22584
161, 0.18849432, 0, -198.00059
162, -15.433186, 0, -202.2742
163, -26.105513, 0, -213.21818
164, -25.96504, 0, -243.0272
165, -14.945553, 0, -254.01212
166, 0.094247625, 0, -257.99985
167, 15.027199, 0, -253.96504
168, 26.012121, 0, -242.94555
169, -132.23446, 0, -168.95457
170, -132.23446, 0, -153.48612
171, -139.9406, 0, -140.07389
172, -153.30415, 0, -132.28362
173, -168.77229, 0, -132.18643
174, -190.30114, 0, -153.85097
175, -190.10676, 0, -169.31819
176, -182.23268, 0, -182.63253
177, -168.86347, 0, -190.23039
178, -153.3951, 0, -190.1818
179, -212.9728, 0, -25.96504
180, -202.03496, 0, -15.027199
181, -198, 0, -2.4982734e-14
182, -201.98788, 0, 14.945553
183, -212.8913, 0, 25.917703
184, -243.0272, 0, 25.96504
185, -254.05895, 0, 14.86376
186, -257.99985, 0, -0.094247625
187, -253.9177, 0, -15.108696
188, -242.94555, 0, -26.012121
189, -168.95457, 0, 132.23446
190, -153.48612, 0, 132.23446
191, -139.9406, 0, 140.07389
192, -132.23446, 0, 153.48612
193, -132.2589, 0, 169.04559
194, -153.48612, 0, 190.20624
195, -169.04559, 0, 190.1818
196, -182.43355, 0, 182.43355
197, -190.20624, 0, 168.95457
198, -190.1818, 0, 153.3951
199, -25.96504, 0, 212.9728
200, -14.945553, 0, 201.98788
201, 0.094247625, 0, 198.00015
202, 15.027199, 0, 202.03496
203, 26.012121, 0, 213.05445
204, 26.012121, 0, 242.94555
205, 14.86376, 0, 254.05895
206, -0.094247625, 0, 257.99985
207, -15.027199, 0, 253.96504
208, -26.058945, 0, 242.86376
209, 1169.52, 0, -60
210, 1229.8911, 0, 52.024242
211, 1251.8354, 0, 30.217392
212, 1259.9997, 0, 0.18849525
213, 1252.1179, 0, -29.72752
214, 1230.3801, 0, -51.740219
215, 1173.36, 0, 60
216, 1109.9456, 0, -51.93008
217, 1088.0699, 0, -30.054398
218, 1080, 0, -3.6738191e-15
219, 1087.9758, 0, 29.891106
220, 1110.1089, 0, 52.024242
221, 73.846154, 28.44, 290.76923
222, 37.397526, 60, -297.65992
223, 5.83529, 60, -299.94324
224, -23.615886, 60, -299.06904
225, -51.764279, 60, -295.50035
226, -93.041053, 60, -285.20758
227, -133.42563, 60, -268.69611
228, -167.38212, 60, -248.96431
229, -192.67573, 60, -229.94795
230, -216.58237, 60, -207.58631
231, -237.24369, 60, -183.61762
232, -256.97066, 60, -154.80982
233, -276.70784, 60, -115.89984
234, -290.59251, 60, -74.538522
235, -297.96826, 60, -34.855621
236, -299.98212, 60, -3.2750463
237, -298.75938, 60, 27.254962
238, -291.64668, 60, 70.300895
239, -276.28424, 60, 116.90601
240, -253.52955, 60, 160.38319
241, -234.54591, 60, 187.05138
242, -216.58237, 60, 207.58631
243, -193.51124, 60, 229.24528
244, -165.56574, 60, 250.17591
245, -125.54789, 60, 272.46601
246, -73.114852, 60, 290.95398
247, -30.139634, 60, 298.48216
248, 0.37713894, 60, 299.99976
249, 31.975694, 60, 298.29106
250, 1131.7316, 60, -150.50938
251, 1070.3027, 60, -151.83877
252, 997.52917, 60, -154.48246
253, 928.2144, 60, -158.08008
254, 871.44494, 60, -161.81289
255, 807.92389, 60, -166.83136
256, 696.95247, 60, -177.74059
257, 599.81335, 60, -189.53961
258, 502.9488, 60, -203.41348
259, 395.19961, 60, -221.34356
260, 275.64755, 60, -244.353
261, 183.35739, 60, -264.38762
262, 121.33166, 60, -278.97935
263, 1265.9909, 60, 134.70414
264, 1320.5162, 60, 89.307576
265, 1347.8467, 60, 25.325017
266, 1345.1696, 60, -37.759732
267, 1316.1755, 60, -94.885524
268, 1263.4402, 60, -135.92403
269, 124.64927, 60, 278.17576
270, 193.34451, 60, 262.12316
271, 295.71562, 60, 240.25979
272, 420.97504, 60, 216.81355
273, 527.69951, 60, 199.66719
274, 622.38096, 60, 186.61028
275, 720.70914, 60, 175.17525
276, 814.7263, 60, 166.25136
277, 887.33565, 60, 160.69655
278, 960.02421, 60, 156.29815
279, 1055.5173, 60, 152.28202
280, 1130.5939, 60, 150.5265
281, 132.7847, 60, -69.772662
282, 90.063034, 60, -119.9527
283, 50.367058, 60, -141.29105
284, 15.523042, 60, -149.19462
285, -14.585324, 60, -149.28921
286, -49.478312, 60, -141.60472
287, -84.701843, 60, -123.7966
288, -112.20447, 60, -99.549771
289, -133.86426, 60, -67.678363
290, -146.97826, 60, -29.956497
291, -146.6894, 60, 31.340384
292, -131.67237, 60, 71.849745
293, -112.82774, 60, 98.842809
294, -89.307576, 60, 120.51621
295, -60.004371, 60, 137.47536
296, -22.999618, 60, 148.22624
297, 7.5366477, 60, 149.81054
298, 40.035298, 60, 144.55855
299, 85.478002, 60, 123.26196
300, 130.06061, 60, 74.727766
301, 673.86016, 60, 60.108795
302, 630.1088, 60, 103.86016
303, 570, 60, 120
304, 510.21779, 60, 104.04848
305, 465.95152, 60, 59.782213
306, 466.13984, 60, -60.108795
307, 510.21779, 60, -104.04848
308, 570.37699, 60, -119.99941
309, 630.1088, 60, -103.86016
310, 674.04848, 60, -59.782213
311, 977.89512, 60, 45.081596
312, 944.83666, 60, 78.036363
313, 899.71726, 60, 89.999556
314, 854.9184, 60, 77.89512
315, 821.96364, 60, 44.836659
316, 821.96364, 60, -44.836659
317, 854.42987, 60, -77.610328
318, 899.15178, 60, -89.996003
319, 945.81373, 60, -77.466782
320, 978.17684, 60, -44.59128
321, 26.012121, 60, -213.05445
322, 15.108696, 60, -202.0823
323, -0.28273915, 60, -198.00133
324, -15.190044, 60, -202.12989
325, -26.058945, 60, -213.13624
326, -25.96504, 60, -243.0272
327, -14.945553, 60, -254.01212
328, -1.8369095e-15, 60, -258
329, 15.027199, 60, -253.96504
330, 26.012121, 60, -242.94555
331, -132.23446, 60, -168.95457
332, -132.2589, 60, -153.3951
333, -140.07389, 60, -139.9406
334, -153.48612, 60, -132.23446
335, -169.04559, 60, -132.2589
336, -190.20624, 60, -153.48612
337, -190.1818, 60, -169.04559
338, -182.43355, 60, -182.43355
339, -168.95457, 60, -190.20624
340, -153.3951, 60, -190.1818
341, -212.9728, 60, -25.96504
342, -201.98788, 60, -14.945553
343, -198.00015, 60, 0.094247625
344, -202.03496, 60, 15.027199
345, -213.05445, 60, 26.012121
346, -243.0272, 60, 25.96504
347, -254.01212, 60, 14.945553
348, -258, 60, -2.1308915e-14
349, -253.96504, 60, -15.027199
350, -242.94555, 60, -26.012121
351, -168.95457, 60, 132.23446
352, -153.3951, 60, 132.2589
353, -140.00714, 60, 140.00714
354, -132.23446, 60, 153.48612
355, -132.2589, 60, 169.04559
356, -153.48612, 60, 190.20624
357, -169.04559, 60, 190.1818
358, -182.43355, 60, 182.43355
359, -190.20624, 60, 168.95457
360, -190.1818, 60, 153.3951
361, -25.96504, 60, 212.9728
362, -14.945553, 60, 201.98788
363, 0.094247625, 60, 198.00015
364, 15.027199, 60, 202.03496
365, 26.012121, 60, 213.05445
366, 25.96504, 60, 243.0272
367, 14.86376, 60, 254.05895
368, -0.18849432, 60, 257.99941
369, -15.108696, 60, 253.9177
370, -26.012121, 60, 242.94555
371, 1169.52, 60, -60
372, 1109.9456, 60, -51.93008
373, 1088.0699, 60, -30.054398
374, 1080, 60, -3.6738191e-15
375, 1087.9758, 60, 29.891106
376, 1110.1089, 60, 52.024242
377, 1171.98, 60, 60
378, 1229.8911, 60, 52.024242
379, 1251.8354, 60, 30.217392
380, 1259.9997, 60, 0.18849525
381, 1252.1179, 60, -29.72752
382, 1230.3801, 60, -51.740219
383, 132.24558, 360, -70.789173
384, 84.079962, 360, -124.21981
385, 150, 172.2, 1.8369702e-14
386, 150, 274.2, 1.8369702e-14
387, -150, 92.1, -1.8369702e-14
388, -150, 142.2, -1.8369702e-14
389, -150, 212.4, -1.8369702e-14
390, -150, 298.8, -1.8369702e-14
391, -89.355535, 360, -120.48066
392, -136.00327, 360, -63.270131
393, -86.252069, 360, -42.149504
394, -59.090924, 360, -75.658857
395, -59.193835, 360, 75.578369
396, -86.309351, 360, 42.032082
397, -140.34733, 360, 52.939847
398, -113.76308, 360, 97.764825
399, -71.180138, 360, 132.03556
400, 86.252069, 360, 42.149504
401, 59.090924, 360, 75.658857
402, 59.501911, 360, -75.336065
403, 86.423436, 360, -41.797005
404, 84.614714, 360, 123.85617
405, 132.44849, 360, 70.408791
406, 96, 308.88, -2.094146e-14
407, 96, 224.28, -2.094146e-14
408, 96, 129.24, -2.094146e-14
409, 96, 53.64, -2.094146e-14
410, -96, 303.84, 0
411, -96, 226.44, 0
412, -96, 127.44, 0
413, -96, 60.84, 0
414, 30, 44.94, -228
415, 30, 29.94, -228
416, 30, 15, -228
417, -30, 44.94, -228
418, -30, 29.94, -228
419, -30, 15, -228
420, -140.00714, 44.94, -182.43355
421, -140.00714, 29.94, -182.43355
422, -140.00714, 15, -182.43355
423, -182.43355, 44.94, -140.00714
424, -182.43355, 29.94, -140.00714
425, -182.43355, 15, -140.00714
426, -228, 44.94, -30
427, -228, 29.94, -30
428, -228, 15, -30
429, -228, 44.94, 30
430, -228, 29.94, 30
431, -228, 15, 30
432, -182.43355, 44.94, 140.00714
433, -182.43355, 29.94, 140.00714
434, -182.43355, 15, 140.00714
435, -140.00714, 44.94, 182.43355
436, -140.00714, 29.94, 182.43355
437, -140.00714, 15, 182.43355
438, -30, 44.94, 228
439, -30, 29.94, 228
440, -30, 15, 228
441, 30, 44.94, 228
442, 30, 29.94, 228
443, 30, 15, 228
444, 1140, 29.94, -60
445, 1200, 29.94, -60
446, 1140, 29.94, 60
447, 1200, 29.94, 60
448, 26.872886, 0, -279.16475
449, -40.73737, 0, -276.4738
450, -72.918358, 0, -261.28918
451, -117.37935, 0, -245.73162
452, -170.78163, 0, -222.48221
453, -217.44007, 0, -177.68455
454, -225.14172, 0, -150.74284
455, -239.27163, 0, -121.57423
456, -271.1336, 0, -59.179677
457, -267.53268, 0, 47.134014
458, -254.51368, 0, 79.385208
459, -226.03645, 0, 156.1812
460, -163.60583, 0, 223.95743
461, -133.86834, 0, 237.81228
462, 94.706715, 0, 244.2988
463, 149.06435, 0, 206.85202
464, 333.90271, 0, 137.28276
465, 715.42813, 0, 107.22025
466, 1307.0077, 0, -2.8329042
467, 1101.3238, 0, -94.096935
468, 1020.1008, 0, -86.902982
469, 751.22394, 0, -108.71452
470, 434.56986, 0, -125.76842
471, 328.58315, 0, -134.78689
472, 222.03936, 0, -177.09248
473, 149.70443, 0, -200.56756
474, 83.07717, 0, -256.25526
475, 137.21604, 0, 37.833186
476, 98.580475, 0, 100.76104
477, 38.452797, 0, 124.14799
478, -37.601916, 0, 121.87947
479, -95.439719, 0, 88.251579
480, -133.41481, 0, 22.07127
481, -132.80863, 0, -26.30427
482, -87.363533, 0, -88.224812
483, -23.0716, 0, -132.39573
484, 42.3823, 0, -135.14662
485, 97.078508, 0, -98.394747
486, 135.8485, 0, -39.526369
487, 433.7406, 0, 128.38068
488, 402.70238, 0, 54.082993
489, 389.73977, 0, -40.654369
490, 1021.0772, 0, 33.452147
491, 752.48158, 0, 33.773366
492, 764.59472, 0, -50.80312
493, 1024.5227, 0, -24.36551
494, 42.880878, 0, -218.02582
495, 32.200247, 0, -197.71259
496, 13.598682, 0, -185.75504
497, -8.9847306, 0, -184.22474
498, -33.30479, 0, -194.10328
499, -43.055516, 0, -218.60335
500, -40.080433, 0, -240.1304
501, -29.413215, 0, -259.65016
502, -10.0427, 0, -266.36105
503, 6.7993733, 0, -272.04951
504, 30.25467, 0, -258.73481
505, 41.46332, 0, -241.08233
506, -124.67223, 0, -181.39549
507, -115.22392, 0, -159.58704
508, -123.5789, 0, -137.77914
509, -139.49599, 0, -122.03258
510, -161.99916, 0, -116.50646
511, -185.04379, 0, -122.98404
512, -201.07315, 0, -141.01762
513, -204.56865, 0, -162.59353
514, -199.18787, 0, -183.93406
515, -183.59944, 0, -202.59125
516, -160.87034, 0, -205.05802
517, -138.21697, 0, -199.86848
518, -216.73193, 0, -43.366567
519, -196.47651, 0, -30.56631
520, -184.30771, 0, -11.072833
521, -184.84049, 0, 10.842596
522, -196.65431, 0, 30.186382
523, -219.14304, 0, 44.677986
524, -241.31017, 0, 40.503755
525, -256.74513, 0, 29.668284
526, -273.66131, 0, 14.100277
527, -270.4246, 0, -12.22035
528, -257.28499, 0, -28.669389
529, -240.50199, 0, -40.339436
530, -183.25703, 0, 124.32109
531, -158.77921, 0, 113.28661
532, -135.50674, 0, 124.02481
533, -121.44905, 0, 140.45103
534, -115.28692, 0, 163.74775
535, -125.80764, 0, 183.28957
536, -139.99945, 0, 196.65219
537, -158.67965, 0, 204.73139
538, -183.22107, 0, 203.02158
539, -199.50775, 0, 183.97272
540, -204.79696, 0, 163.01921
541, -202.5474, 0, 139.92421
542, -41.513794, 0, 213.56198
543, -28.580856, 0, 196.5713
544, -9.8919141, 0, 187.9751
545, 10.307014, 0, 187.26499
546, 29.486132, 0, 196.00229
547, 42.41793, 0, 213.65186
548, 44.593541, 0, 237.50312
549, 34.332305, 0, 257.65006
550, 14.840179, 0, 274.35568
551, -14.655838, 0, 274.26147
552, -33.923853, 0, 257.21702
553, -43.971949, 0, 237.06122
554, 1189.9132, 0, -92.719841
555, 1225.1316, 0, 91.618279
556, 1265.1039, 0, 68.36514
557, 1291.9259, 0, 36.086963
558, 1279.6044, 0, -26.872261
559, 1267.2576, 0, -66.917522
560, 1228.3736, 0, -91.074909
561, 1154.9104, 0, 101.48437
562, 1190.0023, 0, 91.288357
563, 1067.4092, 0, -54.435737
564, 1061.8989, 0, -19.184615
565, 1056.0105, 0, 15.75139
566, 1067.8404, 0, 63.61337
567, 1111.9429, 0, 93.354896
568, 1013.8713, 0, 89.198562
569, -15.033437, 0, -281.29651
570, -257.10642, 0, -87.799483
571, -276.29345, 0, -31.465243
572, -232.50236, 0, 117.48375
573, -217.19513, 0, 178.53718
574, -92.852537, 0, 244.04961
575, 226.7758, 0, 172.46498
576, 1150.3744, 0, -99.919572
577, -146.53882, 0, -224.94151
578, -84.857867, 0, -224.91603
579, -221.71686, 0, 72.260176
580, 42.897836, 0, 276.29051
581, 254.33306, 0, 73.74176
582, -111.27119, 0, 216.14413
583, 1307.211, 0, -44.165146
584, 61.690443, 0, 255.1081
585, -218.20161, 0, -92.259509
586, 95.736556, 0, -210.62825
587, 238.62053, 0, -96.395031
588, 163.52693, 0, -115.50333
589, -2.7402504, 0, 129.35682
590, -75.512899, 0, 120.02282
591, -124.86323, 0, 64.236587
592, -121.60858, 0, -71.928137
593, -72.784069, 0, -125.68387
594, 333.09008, 0, 37.902842
595, -129.32614, 0, 98.679819
596, 52.382228, 0, -265.27554
597, 173.3747, 0, 108.9964
598, 93.318885, 0, 194.66544
599, 104.5243, 0, -153.09779
600, 201.55151, 0, -8.0034058
601, 786.28324, 0, 88.178558
602, 56.8724, 0, -200.03195
603, -103.81318, 0, -179.60403
604, 36.965571, 0, -174.67505
605, 6.529576, 0, -162.13691
606, -22.560256, 0, -166.96618
607, -59.274273, 0, -205.03757
608, -60.140206, 0, -233.60174
609, 62.78896, 0, -231.02438
610, -191.44959, 0, -50.655974
611, -102.51416, 0, -138.53139
612, -114.74749, 0, -111.60055
613, -146.58408, 0, -97.095711
614, -182.00529, 0, -99.397122
615, -209.99809, 0, -119.52419
616, -118.07123, 0, -196.90141
617, -181.26962, 0, 101.8126
618, -170.63716, 0, -30.829987
619, -161.38009, 0, -0.8383732
620, -171.35947, 0, 28.267854
621, -193.04717, 0, 50.636811
622, -239.86425, 0, 58.266812
623, -239.92206, 0, -62.641098
624, -49.858393, 0, 187.10159
625, -109.41145, 0, 119.69486
626, -96.453728, 0, 144.64567
627, -106.41763, 0, 189.09215
628, -123.59988, 0, 201.18387
629, -201.85377, 0, 117.11865
630, -22.976972, 0, 177.83131
631, -1.2517552, 0, 171.19785
632, 24.203345, 0, 174.32074
633, 53.848849, 0, 188.42241
634, 66.324246, 0, 221.49188
635, -61.068881, 0, 254.22929
636, -62.861348, 0, 221.40447
637, -42.189905, 0, 276.11529
638, -161.36973, 0, -65.487126
639, -65.700668, 0, 157.92554
640, -138.26854, 0, 215.69501
641, -119.52269, 0, -218.33253
642, -88.150875, 0, -159.1837
643, -206.91522, 0, 95.563082
644, -213.02172, 0, -64.679191
645, -52.903681, 0, -166.33207
646, 68.175188, 0, -173.73174
647, 13.391204, 0, 151.33831
648, -159.43833, 0, 53.722064
649, -25.367438, 0, 154.04293
650, -155.90985, 0, 85.090538
651, -92.001404, 0, 170.01668
652, -49.281164, 0, -255.08152
653, 119.94766, 0, 153.69963
654, 75.71246, 0, 153.6715
655, -257.80897, 0, -45.776134
656, -81.466815, 0, 196.35539
657, 287.97265, 0, -30.122053
658, -79.242027, 0, -188.713
659, -186.44061, 0, 74.666686
660, 41.167196, 0, 157.63404
661, -192.80874, 0, -76.022433
662, -99.285527, 0, -202.17366
663, 15.946031, 29.863895, -299.57591
664, -11.279459, 30.043013, -299.78788
665, -37.69503, 29.943278, -297.62239
666, -74.980894, 29.926298, -290.47868
667, -180.1235, 29.907585, -239.90732
668, -205.06091, 30.039753, -218.97493
669, -227.43263, 29.963469, -195.63844
670, -247.2169, 30.115955, -169.95236
671, -267.72664, 30.0044, -135.36043
672, -284.24104, 29.967921, -95.95328
673, -294.80697, 30.734146, -55.577426
674, -299.31107, 30.73401, -20.319582
675, -299.75784, 30.140475, 12.051502
676, -296.35307, 29.707997, 46.63538
677, -286.17837, 29.99388, 90.010771
678, -266.75675, 29.876544, 137.26193
679, -245.77063, 29.986334, 172.03719
680, -227.20053, 29.98287, 195.90793
681, -207.00535, 29.917496, 217.13771
682, -180.61055, 29.978136, 239.54087
683, -151.63464, 29.814706, 258.85698
684, -14.150561, 29.846092, 299.66608
685, 19.099818, 29.127457, 299.39138
686, -152.12617, 29.631149, -258.56842
687, -114.73242, 29.919139, -277.19392
688, -45.039245, 30.06948, 296.59984
689, 98.804671, 28.808127, 284.50522
690, 21.298452, 60, -280.89581
691, -30.024462, 60, -278.16488
692, -89.95835, 60, -242.23345
693, -164.71762, 60, -223.45963
694, -217.10953, 60, -177.66808
695, -236.39964, 60, -118.92225
696, -265.02604, 60, -51.127207
697, -254.74563, 60, 79.61399
698, -224.53638, 60, 158.97149
699, -164.87869, 60, 224.36346
700, -89.234625, 60, 243.78672
701, 1101.2442, 60, -93.621706
702, 330.18588, 60, -148.33471
703, 143.62514, 60, -211.57002
704, 88.711837, 60, 245.91742
705, 237.94006, 60, 170.81538
706, 755.31304, 60, 104.55053
707, 197.52961, 60, -45.885415
708, 157.95248, 60, -139.12543
709, 101.49101, 60, -171.94282
710, -6.3171112, 60, -169.24115
711, -85.772293, 60, -165.98898
712, -110.54061, 60, -123.93555
713, -152.46045, 60, -95.02847
714, -168.12555, 60, -59.145147
715, -172.26785, 60, -20.154146
716, -168.89526, 60, 17.747696
717, -175.45564, 60, 57.929999
718, -148.3018, 60, 90.958959
719, -112.02091, 60, 127.87757
720, -86.135268, 60, 150.90268
721, -55.163511, 60, 165.33952
722, -2.8545106, 60, 168.87601
723, 30.645767, 60, 171.24858
724, 91.322428, 60, 182.19148
725, 152.34881, 60, 164.71653
726, 219.48032, 60, 65.179213
727, 722.57727, 60, 49.362008
728, 688.26513, 60, 112.63515
729, 443.71075, 60, 131.49362
730, 400.82547, 60, 63.18493
731, 402.09383, 60, -66.107633
732, 439.54681, 60, -131.135
733, 732.46617, 60, -30.24966
734, 1016.2069, 60, 30.569913
735, 1004.3161, 60, 93.194192
736, 809.18497, 60, 89.826631
737, 775.17599, 60, 34.739123
738, 780.18019, 60, -27.384207
739, 1025.9925, 60, -23.550539
740, 43.883731, 60, -223.00468
741, 29.578595, 60, -193.35401
742, 9.1466358, 60, -186.04921
743, -11.370352, 60, -188.20958
744, -30.879685, 60, -200.31699
745, -40.581536, 60, -219.2014
746, -41.827241, 60, -240.32202
747, -30.870548, 60, -257.69476
748, -11.852648, 60, -267.74234
749, 7.8304594, 60, -268.95006
750, 29.13781, 60, -259.59873
751, 40.160567, 60, -242.97588
752, -126.76638, 60, -183.74288
753, -115.77516, 60, -166.68275
754, -126.86682, 60, -134.21432
755, -143.91806, 60, -122.11507
756, -164.64806, 60, -118.25808
757, -184.09684, 60, -125.81584
758, -199.27627, 60, -140.84087
759, -204.37541, 60, -162.20027
760, -199.10732, 60, -183.96996
761, -182.66758, 60, -203.03662
762, -160.34081, 60, -203.72801
763, -140.64476, 60, -196.77069
764, -216.4118, 60, -41.458872
765, -197.15859, 60, -29.449285
766, -188.98319, 60, -12.538585
767, -185.03315, 60, 6.724093
768, -193.05874, 60, 29.787081
769, -214.41692, 60, 46.549605
770, -236.92767, 60, 41.715141
771, -256.74759, 60, 32.452551
772, -273.53066, 60, 14.12562
773, -273.49637, 60, -17.190092
774, -255.59322, 60, -30.73508
775, -239.70438, 60, -41.534234
776, -182.65615, 60, 121.97874
777, -157.63945, 60, 114.03083
778, -136.21217, 60, 127.25448
779, -124.11141, 60, 142.88126
780, -119.46318, 60, 161.76276
781, -122.84844, 60, 184.54147
782, -140.80221, 60, 197.08477
783, -160.63569, 60, 204.41097
784, -187.13845, 60, 201.68063
785, -196.99394, 60, 180.3658
786, -204.34203, 60, 163.84974
787, -202.80486, 60, 139.30159
788, -45.002436, 60, 215.82176
789, -30.400805, 60, 196.45122
790, -11.331551, 60, 187.00517
791, 11.113328, 60, 186.27802
792, 30.898714, 60, 196.70362
793, 44.896764, 60, 217.90493
794, 41.423549, 60, 241.74792
795, 30.855939, 60, 259.57273
796, 13.475677, 60, 274.71465
797, -14.715404, 60, 273.99852
798, -32.094562, 60, 258.10829
799, -42.068754, 60, 239.40298
800, 1192.3315, 60, -93.330243
801, 1151.4173, 60, -99.754024
802, 1067.6334, 60, -53.550702
803, 1061.152, 60, -18.192976
804, 1055.2885, 60, 19.518148
805, 1080.0737, 60, 60.211248
806, 1113.9609, 60, 86.602752
807, 1154.7451, 60, 100.79357
808, 1190.0325, 60, 90.736347
809, 1227.2711, 60, 90.02657
810, 1267.6832, 60, 63.174095
811, 1281.4011, 60, 17.722358
812, 1281.241, 60, -18.804906
813, 1268.3283, 60, -57.34271
814, 1236.4222, 60, -91.376807
815, 781.41593, 60, -88.840452
816, 1024.3816, 60, -86.754085
817, -4.9492942, 60, -283.08092
818, -56.140327, 60, -260.58142
819, -132.19122, 60, -235.19369
820, -224.42582, 60, -150.09266
821, -250.53338, 60, -84.594132
822, -274.282, 60, 47.069894
823, -232.34901, 60, 123.34735
824, -213.16176, 60, 184.8231
825, -130.26386, 60, 234.0193
826, 706.46773, 60, -96.143038
827, 216.31033, 60, -188.9886
828, 90.807788, 60, -231.48453
829, 1312.9211, 60, -2.5647441
830, 1305.9677, 60, -44.411792
831, 334.76132, 60, 137.53498
832, 852.85499, 60, 120.54791
833, 60.03219, 60, -185.64056
834, 381.15536, 60, -2.4448218
835, 43.297272, 60, -205.4668
836, -44.414758, 60, -166.41121
837, -202.69213, 60, -85.683568
838, -39.582539, 60, 276.40047
839, 1306.8746, 60, 39.683638
840, 1070.4299, 60, 103.48575
841, -57.809942, 60, 257.14414
842, 58.875475, 60, -236.575
843, 52.539036, 60, -266.29554
844, 27.760752, 60, -170.62788
845, -78.43753, 60, 182.10119
846, 259.7993, 60, -17.37764
847, -206.74638, 60, -120.18633
848, -61.406001, 60, -228.87241
849, -123.62287, 60, -204.93282
850, -228.15976, 60, -62.553297
851, -109.00452, 60, -185.17318
852, -232.68418, 60, 60.995833
853, -202.40895, 60, 112.00945
854, -195.47053, 60, -52.433318
855, -107.79333, 60, 151.14322
856, -101.94585, 60, 172.3286
857, -126.23633, 60, 207.06831
858, -61.758991, 60, 233.01521
859, -178.60749, 60, 95.585895
860, 53.501141, 60, 195.31282
861, 63.757659, 60, 243.22123
862, 50.366745, 60, 261.53464
863, -52.040762, 60, 191.35285
864, 247.7023, 60, -102.01786
865, 38.747935, 60, 278.05886
866, -98.422786, 60, -209.2852
867, -213.92337, 60, 80.84571
868, 1044.087, 60, 62.728907
869, 69.390398, 60, 215.97944
870, -72.121763, 60, 211.0247
871, -251.65503, 60, 53.150801
872, 316.33932, 60, 36.961013
873, -108.67399, 60, -145.52612
874, -133.41451, 60, 110.15836
875, -28.741305, 60, 174.63041
876, -70.865868, 60, -197.38939
877, -128.94787, 60, -113.73376
878, 322.77303, 60, -51.040164
879, -50.752056, 60, -207.15397
880, -183.53988, 60, -107.40354
881, -144.1381, 60, -214.59994
882, -144.12108, 60, 214.73977
883, -101.27045, 60, 205.2715
884, -26.673834, 60, -181.04873
885, -45.083673, 60, -189.27581
886, 60.335594, 60, -215.5247
887, 100.24557, 304.71945, -111.58327
888, 124.40187, 245.25522, -83.810353
889, 70.77552, 106.82139, -132.25289
890, 0.16826364, 87.305666, -149.99991
891, -70.730247, 98.025653, -132.2771
892, -124.77803, 88.176568, -83.249286
893, -134.71401, 175.10772, -65.970719
894, -128.45661, 276.40972, -77.45256
895, 8.1735475, 248.31006, -149.77714
896, 114.79297, 139.32317, -96.553478
897, -142.85059, 105.8181, -45.757059
898, 58.706758, 317.33115, -138.03448
899, 32.6339, 101.02601, -146.40706
900, -32.466791, 94.304028, -146.44421
901, -101.77899, 96.368753, -110.18637
902, 62.379965, 264.00422, -136.41386
903, -46.883763, 248.97149, -142.48478
904, -83.306161, 286.88102, -124.74006
905, 48.643684, 178.33015, -141.89359
906, -2.5974, 134.31495, -149.97751
907, -93.051172, 150.01439, -117.64982
908, -122.03038, 126.43262, -87.22721
909, -48.953787, 135.0005, -141.78691
910, -33.255442, 189.26775, -146.26714
911, -96.538841, 217.70052, -114.80528
912, 4.6650397, 260.90386, -95.886586
913, 72.699999, 315.56558, -62.695376
914, 62.396118, 169.83718, -72.957004
915, 68.214456, 70.310342, -67.548412
916, -73.179473, 45.166803, -62.135052
917, 20.996416, 49.203095, -93.675773
918, -82.768638, 257.32375, -48.634891
919, -72.323736, 98.330343, -63.129052
920, -71.682743, 308.75357, -63.855966
921, 56.537082, 254.87732, -77.585813
922, -30.898545, 54.718646, -90.891583
923, -65.018095, 176.13593, -70.630357
924, -39.790669, 254.38491, -87.36534
925, -4.2303126, 116.17001, -95.906749
926, 4.2697797, 206.97062, -95.905
927, -15.220205, 237.64247, 94.785787
928, -74.972101, 262.43355, 59.959853
929, -77.212691, 177.27023, 57.045599
930, -78.657706, 93.280215, 55.036037
931, 71.949118, 41.158024, 63.55568
932, -34.979265, 60.870644, 89.400509
933, 69.767667, 184.83495, 65.942949
934, 71.100647, 99.190077, 64.503473
935, 74.948826, 288.38772, 59.988944
936, -75.289821, 317.45196, 59.560413
937, 28.343335, 55.143416, 91.720529
938, 37.919734, 244.26119, 88.193502
939, -36.74366, 139.96277, 88.689929
940, 18.600716, 114.99538, 94.180748
941, 19.555862, 186.81206, 93.987064
942, -132.34863, 311.11467, 70.596318
943, -97.477891, 296.61151, 114.00904
944, -142.9305, 106.24061, 45.506826
945, -139.3475, 171.11792, 55.518232
946, -125.19176, 91.520018, 82.625797
947, -75.996859, 95.366081, 129.32315
948, -6.4602035, 103.15901, 149.86082
949, 62.65975, 106.9967, 136.28557
950, 124.74419, 209.29274, 83.299986
951, 111.88431, 289.77133, 99.909469
952, -1.5562156, 261.26184, 149.99193
953, -133.45133, 247.34765, 68.489005
954, -103.38827, 95.178731, 108.6778
955, -41.471525, 99.188671, 144.15309
956, 26.872986, 95.218272, 147.57318
957, 106.06872, 116.86323, 106.06332
958, 140.9056, 123.54506, 51.435516
959, 61.172761, 309.40778, 136.95946
960, 50.020022, 240.67238, 141.41428
961, -47.488635, 262.7961, 142.28433
962, -55.092514, 314.80159, 139.51636
963, -86.473905, 188.85972, 122.56534
964, -93.061856, 129.14589, 117.64137
965, -121.06489, 134.30678, 88.562364
966, 74.452995, 166.1237, 130.21809
967, -12.036274, 208.22454, 149.51631
968, 23.604837, 148.29334, 148.13106
969, -26.42529, 148.95024, 147.654
970, -63.262025, 132.77263, 136.00704
971, 22.751494, 14.019665, -208.44573
972, -6.5781853, 15.485378, -198.73009
973, 28.179871, 36.151003, -217.70948
974, 20.021211, 49.14837, -205.65831
975, 8.2447201, 46.170241, -199.15516
976, -6.9277271, 45.50401, -198.81085
977, -20.063386, 45.447836, -205.69618
978, -27.843849, 45.000234, -216.83219
979, -27.582236, 18.771694, -216.20084
980, 9.3871061, 15.61873, -199.50645
981, -19.915996, 16.111487, -205.56447
982, 27.577772, 24.675848, -216.19041
983, 27.203799, 47.63283, -215.35274
984, 2.0037047, 30.961361, -198.06699
985, -24.577687, 31.256054, -210.79717
986, 19.352337, 33.042144, -205.0765
987, -13.283473, 30.770768, -201.10113
988, -22.69298, 14.027359, -247.62215
989, 6.4020267, 15.274407, -257.30894
990, -28.208273, 36.195897, -238.21241
991, -20.020995, 49.19846, -250.34188
992, -8.2324569, 46.36533, -256.84834
993, 7.0310949, 45.386088, -257.16443
994, 20.749212, 44.782742, -249.66726
995, 28.144295, 49.322842, -238.38743
996, 27.898648, 36.473866, -239.03021
997, 27.574797, 21.025294, -239.81654
998, -9.3101046, 15.27346, -256.5188
999, 19.575122, 15.767261, -250.73356
1000, -27.60353, 24.698007, -239.74926
1001, -27.207686, 47.670897, -240.6389
1002, 12.604619, 30.329284, -255.22358
1003, -19.714391, 33.089966, -250.61289
1004, 22.474861, 29.684302, -247.8716
1005, -1.8341903, 30.81135, -257.94388
1006, -131.29942, 14.046513, -163.39708
1007, -144.85025, 15.359092, -136.08034
1008, -134.02271, 36.185884, -173.88086
1009, -131.26786, 49.168349, -159.53255
1010, -134.97719, 46.132399, -146.6843
1011, -145.49612, 45.345315, -135.6714
1012, -160.51832, 44.781985, -131.22856
1013, -173.76202, 49.317514, -133.9677
1014, -173.10808, 36.463953, -133.67617
1015, -172.28001, 21.016148, -133.33336
1016, -134.40667, 15.598479, -147.76572
1017, -158.81314, 15.788306, -131.31708
1018, -133.36928, 24.696487, -172.37016
1019, -133.03314, 47.656536, -171.49077
1020, -150.68969, 30.352504, -133.12933
1021, -131.31609, 33.053053, -158.82549
1022, -162.94267, 29.690541, -131.26983
1023, -138.42316, 30.890116, -141.71937
1024, -191.15487, 14.066885, -159.23941
1025, -177.53847, 15.407424, -186.39412
1026, -188.42261, 36.188319, -148.56978
1027, -191.17317, 49.175761, -162.90219
1028, -187.48369, 46.132614, -175.71989
1029, -177.04143, 45.337981, -186.70943
1030, -162.33985, 44.624912, -191.19945
1031, -148.40099, 49.383713, -188.34347
1032, -149.2708, 36.28502, -188.73776
1033, -149.8835, 21.336902, -188.9958
1034, -187.95094, 15.604975, -174.83929
1035, -163.92695, 16.002788, -191.098
1036, -189.08913, 24.699726, -150.1149
1037, -189.40754, 47.659335, -150.94989
1038, -171.7867, 30.382216, -189.29796
1039, -191.12249, 33.069523, -163.64151
1040, -159.51226, 29.71252, -191.17168
1041, -184.01592, 30.906234, -180.72322
1042, -208.3751, 14.046083, -22.690602
1043, -198.6596, 15.357962, 6.2562863
1044, -217.71899, 36.185295, -28.183344
1045, -205.62505, 49.167219, -19.984032
1046, -199.16304, 46.130119, -8.27224
1047, -198.81783, 45.343683, 6.9570725
1048, -206.30292, 44.782134, 20.718032
1049, -217.60087, 49.319016, 28.139974
1050, -216.93873, 36.467728, 27.886348
1051, -216.12511, 21.021951, 27.54972
1052, -199.51572, 15.592241, -9.4151959
1053, -205.1883, 15.790934, 19.484
1054, -216.18748, 24.6958, -27.576517
1055, -215.32967, 47.655965, -27.193063
1056, -200.70406, 30.351635, 12.447166
1057, -205.15654, 33.050983, -19.446752
1058, -208.05962, 29.693254, 22.413865
1059, -198.08894, 30.886, -2.3083166
1060, -247.68725, 14.024568, 22.636523
1061, -257.27306, 15.532168, -6.5641368
1062, -238.30775, 36.15808, 28.173576
1063, -250.37454, 49.16532, 19.984489
1064, -256.82969, 46.148144, 8.2975186
1065, -257.21596, 45.519881, -6.8137937
1066, -250.36695, 45.463527, -19.992992
1067, -239.20842, 45.007369, -27.827526
1068, -239.86629, 18.767937, -27.553422
1069, -256.53898, 15.641023, 9.2480467
1070, -250.51423, 16.109207, -19.826988
1071, -239.85203, 24.677247, 27.559562
1072, -240.67757, 47.643673, 27.189691
1073, -257.93226, 30.981058, 2.0148631
1074, -245.26583, 31.263822, -24.533468
1075, -250.94437, 33.057157, 19.32759
1076, -254.92851, 30.795635, -13.223294
1077, -163.38025, 14.045872, 131.2982
1078, -136.01701, 15.355978, 144.94792
1079, -173.87913, 36.18481, 134.02191
1080, -159.53497, 49.167658, 131.26773
1081, -146.69704, 46.122311, 134.97013
1082, -135.67058, 45.34578, 145.49745
1083, -131.22817, 44.78242, 160.53509
1084, -133.97032, 49.320561, 173.76769
1085, -133.6849, 36.472123, 173.12829
1086, -133.35708, 21.028394, 172.33962
1087, -147.70815, 15.585074, 134.43564
1088, -131.30712, 15.788444, 158.9402
1089, -172.36556, 24.69525, 133.36744
1090, -171.49096, 47.65593, 133.03321
1091, -133.10572, 30.349963, 150.75288
1092, -158.81734, 33.049067, 131.31674
1093, -131.27327, 29.694936, 163.00148
1094, -141.69239, 30.880532, 138.44626
1095, -159.10536, 14.026204, 191.1457
1096, -186.53126, 15.529734, 177.32493
1097, -148.58407, 36.158698, 188.42925
1098, -162.90638, 49.165871, 191.17293
1099, -175.73195, 46.148927, 187.47703
1100, -186.69174, 45.518536, 177.06989
1101, -191.17289, 45.460825, 162.90715
1102, -188.82438, 45.00427, 149.47227
1103, -189.09937, 18.762551, 150.14064
1104, -174.81583, 15.640552, 187.96287
1105, -191.15789, 16.099594, 163.15521
1106, -150.10523, 24.678459, 189.08527
1107, -150.95677, 47.644136, 189.41004
1108, -180.9373, 30.980312, 183.831
1109, -190.78002, 31.259277, 156.09923
1110, -163.76585, 33.057256, 191.11216
1111, -189.60275, 30.79115, 170.93832
1112, -22.669733, 14.044274, 208.351
1113, 6.3255162, 15.356385, 198.67445
1114, -28.182024, 36.184444, 217.71537
1115, -19.980637, 49.166186, 205.62202
1116, -8.2633207, 46.127949, 199.16049
1117, 6.9712912, 45.341639, 198.82122
1118, 20.727806, 44.78142, 206.31226
1119, 28.141543, 49.320785, 217.60512
1120, 27.891633, 36.472179, 216.95207
1121, 27.565836, 21.028381, 216.16257
1122, -9.3584689, 15.590622, 199.49703
1123, 19.543234, 15.787989, 205.23902
1124, -27.572785, 24.694322, 216.17877
1125, -27.192073, 47.655303, 215.32754
1126, 12.488172, 30.348504, 200.7228
1127, -19.43684, 33.049896, 205.1481
1128, 22.438857, 29.694202, 208.08775
1129, -2.2750593, 30.882916, 198.08639
1130, 22.34184, 12.251107, 248.02104
1131, -6.595749, 14.946694, 257.26595
1132, 27.175308, 40.628646, 240.70837
1133, 20.109212, 48.912718, 250.26252
1134, 8.1760877, 46.519254, 256.86437
1135, -6.7053472, 45.327893, 257.24104
1136, -19.938729, 45.347701, 250.41533
1137, -27.816984, 44.96349, 239.23456
1138, -27.546423, 18.721947, 239.88253
1139, 8.4486016, 13.134057, 256.78578
1140, -19.806379, 15.926988, 250.53236
1141, 26.39617, 26.044677, 242.2563
1142, 3.0263683, 29.987205, 257.84696
1143, 17.882507, 35.81647, 252.08767
1144, -24.477422, 31.158713, 245.3452
1145, 16.236678, 23.468051, 253.22638
1146, -12.976555, 30.44542, 255.04827
1147, 1099.3496, 29.994264, -44.131003
1148, 1082.1624, 29.999069, -15.962912
1149, 1082.1473, 29.999078, 15.908099
1150, 1099.3623, 29.994316, 44.142694
1151, 1240.5235, 29.994233, 44.247509
1152, 1257.7862, 29.999063, 16.148017
1153, 1257.9103, 29.999073, -15.696885
1154, 1240.8851, 29.994319, -43.913609
1155, 62.417904, 29.480164, -251.60786
1156, 46.682544, 23.941827, -191.70838
1157, 70.769644, 34.812282, -201.03751
1158, 39.951215, 37.713646, -172.08314
1159, 39.574669, 23.363617, -223.22715
1160, 10.693943, 29.902054, -159.31738
1161, -22.196233, 34.655873, -167.04786
1162, -32.492643, 37.156924, -191.47835
1163, -44.685987, 42.104949, -220.87591
1164, -61.118939, 34.546952, -250.07888
1165, -94.481792, 26.049461, -245.37442
1166, -49.138514, 28.651565, -271.76005
1167, 35.18959, 30.936267, -268.73804
1168, -110.8377, 20.550822, -158.21617
1169, -116.78513, 15.540847, -180.06125
1170, -130.40775, 32.422565, -125.212
1171, -134.90693, 33.650098, -219.66216
1172, -107.37058, 23.744742, -120.66116
1173, -172.88578, 39.201649, -118.75793
1174, -170.15308, 32.535946, -92.550869
1175, -232.25689, 29.628943, -139.369
1176, -199.90454, 36.942286, -110.07291
1177, -253.43856, 28.518453, -62.816241
1178, -218.86744, 28.059262, -42.238066
1179, -196.89093, 30.007072, -37.78491
1180, -178.44296, 32.268836, -2.7850434
1181, -187.20924, 31.698789, -21.509372
1182, -185.36421, 30.518365, 19.481482
1183, -197.06615, 26.591253, 41.73461
1184, -258.93982, 31.091474, 61.399931
1185, -272.0383, 19.15833, -41.497618
1186, -105.82396, 34.131385, 139.3414
1187, -107.97698, 26.763562, 101.54809
1188, -139.96299, 29.816095, 72.199741
1189, -87.679841, 28.346921, 166.54812
1190, -230.52742, 30.485965, 143.4749
1191, -64.778196, 30.592537, 241.24628
1192, -19.088458, 30.333719, 170.95924
1193, -35.169682, 38.854037, 191.59322
1194, 39.95883, 28.278438, 214.39127
1195, -1.996363, 28.326888, 155.79503
1196, -44.52531, 20.356086, 225.68658
1197, 35.278676, 29.394015, 196.13774
1198, 19.137941, 32.003824, 169.26229
1199, 59.642953, 29.990898, 237.46809
1200, 39.091403, 29.190522, 238.43313
1201, 64.034527, 32.921888, 262.94534
1202, 0.93563905, 29.98468, 275.44925
1203, -50.431583, 30.875433, 268.00111
1204, 1187.877, 29.877941, -90.002774
1205, -56.995782, 36.302205, 209.93905
1206, 39.729477, 37.349541, -228.55988
1207, 55.397835, 28.656919, -223.78471
1208, 76.224374, 26.470576, -225.91404
1209, 107.13851, 31.331945, -230.18415
1210, 39.920871, 36.398877, -213.66478
1211, 41.55989, 44.876278, -200.49296
1212, 72.361295, 29.750809, -163.6731
1213, 37.566222, 16.878679, -207.85211
1214, 1.4384495, 45.142488, -182.44883
1215, 20.510071, 42.608555, -188.41522
1216, 23.361468, 16.938711, -186.94101
1217, 8.7329905, 26.65295, -186.79129
1218, -0.38962162, 13.672907, -180.15924
1219, -17.718378, 44.754234, -188.37448
1220, -52.100465, 26.717904, -180.39873
1221, -7.1933209, 30.428097, -185.35524
1222, -62.845099, 30.356639, -202.4153
1223, -92.630528, 29.672276, -178.79498
1224, -59.569167, 25.439201, -155.99438
1225, -21.643475, 18.436422, -186.82084
1226, -37.993957, 44.291614, -206.23825
1227, -63.933269, 31.85166, -226.66646
1228, -38.875402, 17.777883, -203.29818
1229, -40.047431, 28.201103, -217.47368
1230, -44.474918, 13.489698, -222.32103
1231, -42.032105, 44.23201, -235.28808
1232, -41.655823, 28.414227, -234.38228
1233, -41.492393, 14.899171, -245.10055
1234, -35.946764, 29.612478, -251.29464
1235, -24.951189, 41.461211, -268.83411
1236, -5.0318955, 41.483246, -270.41925
1237, -36.121376, 45.59026, -251.74987
1238, -6.5601179, 18.067101, -271.79183
1239, 13.723262, 42.685975, -272.15118
1240, 13.434871, 19.350317, -272.28003
1241, -27.063915, 16.623385, -268.07748
1242, 36.574991, 31.555253, -248.44299
1243, 41.413103, 46.471514, -243.10538
1244, 40.050657, 15.34077, -251.38045
1245, 40.427058, 27.29202, -236.50747
1246, 42.901664, 12.913494, -233.96011
1247, -124.32671, 29.417257, -197.57995
1248, -121.88582, 36.651301, -178.15471
1249, -111.87999, 43.83736, -165.30163
1250, -118.177, 36.107465, -142.90071
1251, -86.488063, 34.70637, -137.14458
1252, -132.58658, 28.12614, -94.222248
1253, -152.17366, 40.939523, -115.97269
1254, -149.63646, 18.9565, -117.21375
1255, -168.76289, 17.818473, -115.63727
1256, -188.46706, 44.920693, -126.91209
1257, -186.77016, 23.609257, -121.01568
1258, -201.08127, 38.801521, -136.30043
1259, -232.51356, 30.337759, -106.47156
1260, -202.01809, 20.83789, -90.673556
1261, -203.02943, 18.644334, -136.49958
1262, -207.7312, 39.293013, -155.70665
1263, -205.68199, 36.094495, -181.67733
1264, -209.07351, 18.851901, -161.53162
1265, -161.83816, 44.003881, -204.58747
1266, -161.03316, 35.253373, -227.47103
1267, -174.55687, 16.54106, -209.48695
1268, -154.75403, 21.070408, -206.08991
1269, -224.69166, 27.855263, -67.292825
1270, -237.05422, 28.271439, -40.57816
1271, -227.85089, 44.014527, -42.561003
1272, -210.49299, 14.175003, -43.296982
1273, -208.7836, 45.396324, -40.636573
1274, -171.70866, 34.734734, -48.849885
1275, -197.17824, 30.820071, -63.495046
1276, -160.06924, 23.621098, -26.083208
1277, -146.5949, 27.66842, 22.953487
1278, -223.19525, 29.314764, 51.081562
1279, -237.9628, 28.805858, 87.394373
1280, -240.11052, 40.319764, 42.912942
1281, -244.23111, 18.131691, 42.793574
1282, -276.42265, 35.592948, 11.244652
1283, -273.83016, 13.580151, 1.374957
1284, -267.84047, 25.458002, -5.8089838
1285, -272.35905, 42.678174, -5.5326289
1286, -260.09848, 39.549402, 33.167338
1287, -266.31206, 18.306674, 28.282162
1288, -267.28766, 36.428129, -26.246267
1289, -282.97042, 19.062894, -14.164742
1290, -266.08928, 15.120086, -19.422369
1291, -251.03061, 41.436567, -41.135865
1292, -251.51728, 17.042969, -37.775622
1293, -232.63802, 13.289641, -44.905804
1294, -160.38463, 29.422925, 97.174275
1295, -202.18142, 30.432694, 134.59834
1296, -196.9121, 30.744175, 101.07635
1297, -185.83923, 39.584465, 125.16688
1298, -179.42702, 44.257398, 109.13402
1299, -190.09729, 26.369974, 74.317082
1300, -221.73872, 30.691372, 112.70762
1301, -184.11379, 21.125773, 120.46651
1302, -168.07045, 41.224405, 120.0532
1303, -164.43417, 21.296633, 116.78561
1304, -146.07271, 18.816109, 117.94025
1305, -142.48717, 41.826862, 120.99547
1306, -133.49886, 44.655413, 101.20002
1307, -119.02421, 15.130321, 143.2727
1308, -73.822257, 28.466435, 128.87337
1309, -126.50725, 24.279039, 128.9097
1310, -113.66111, 42.878087, 165.62204
1311, -115.1928, 23.943666, 159.38933
1312, -120.08062, 44.745684, 152.21672
1313, -119.53734, 31.669131, 185.32802
1314, -89.418644, 31.843616, 196.53729
1315, -117.09537, 27.508942, 221.28742
1316, -142.54089, 28.867517, 209.09116
1317, -136.15799, 45.416511, 194.88037
1318, -166.09783, 33.444112, 206.17338
1319, -204.61747, 40.834438, 181.40759
1320, -206.53609, 41.771949, 156.51874
1321, -202.34023, 18.72599, 185.44011
1322, -208.86939, 19.523618, 159.69236
1323, -38.138152, 31.384638, 212.86951
1324, -83.690283, 30.531376, 221.70613
1325, -41.854387, 35.777197, 228.85177
1326, -39.107443, 44.972016, 219.01802
1327, -46.149451, 48.951619, 230.03661
1328, -49.222244, 29.227963, 172.52334
1329, -38.786131, 17.110967, 205.0381
1330, -36.139022, 46.259528, 205.82806
1331, 1.3373622, 42.126854, 184.34504
1332, -18.264759, 44.353148, 188.42889
1333, -24.391899, 29.910597, 128.65111
1334, -22.823022, 18.442535, 190.331
1335, 0.39272321, 17.659596, 183.50631
1336, 54.590301, 28.563374, 172.36012
1337, 63.780967, 27.082862, 209.89005
1338, 26.931208, 29.060853, 136.26302
1339, 19.668139, 45.017978, 190.7394
1340, 17.863437, 15.040787, 190.33047
1341, 45.196951, 44.729605, 213.33163
1342, 41.2657, 12.906691, 212.0918
1343, 41.533916, 34.73729, 226.93503
1344, 44.895637, 20.200742, 226.52869
1345, 44.864295, 46.832199, 238.90048
1346, 37.4332, 38.672289, 253.13966
1347, 41.614431, 16.924052, 249.15026
1348, 25.255788, 29.294292, 267.65212
1349, -34.273295, 40.639231, 257.7088
1350, -22.710205, 30.31056, 273.81874
1351, -42.118685, 27.765003, 244.08704
1352, -45.220083, 45.920347, 246.43516
1353, -35.28926, 19.134051, 256.24971
1354, 1130.6562, 30.041804, -84.744391
1355, 1046.5374, 29.930911, 1.5342641
1356, 1055.1634, 29.998736, -33.83515
1357, 1060.9352, 30.739043, 35.881822
1358, 1127.9122, 29.982865, 86.64734
1359, 1174.6935, 30.015754, 85.302491
1360, 1172.8132, 30.043909, 118.16158
1361, 1222.4848, 29.902682, 89.961597
1362, 1290.8161, 31.642965, -15.152491
1363, 1287.7617, 28.962596, 25.353849
*Element, type=C3D4, ELSET=PART1
1, 335, 1012, 334, 756
2, 1271, 1067, 775, 1291
3, 1245, 416, 1246, 1159
4, 1178, 1275, 1179, 1272
5, 764, 775, 1271, 39
6, 227, 819, 228, 686
7, 905, 926, 902, 895
8, 1291, 1177, 1271, 1270
9, 1266, 819, 1171, 686
10, 1358, 1150, 566, 805
11, 1080, 1305, 352, 1081
12, 1150, 1358, 446, 376
13, 1237, 1166, 818, 1235
14, 638, 610, 1274, 1275
15, 481, 592, 289, 916
16, 494, 1246, 609, 505
17, 280, 108, 279, 840
18, 291, 387, 413, 30
19, 290, 919, 897, 413
20, 1267, 667, 1266, 452
21, 1267, 667, 668, 1266
22, 1266, 819, 881, 1171
23, 791, 364, 1339, 792
24, 852, 1279, 697, 1184
25, 464, 100, 487, 831
26, 921, 898, 887, 902
27, 1180, 619, 1182, 521
28, 1180, 1046, 1181, 1059
29, 708, 485, 599, 588
30, 588, 486, 600, 707
31, 1043, 1180, 1182, 521
32, 699, 783, 1318, 784
33, 823, 240, 239, 678
34, 793, 441, 1341, 1345
35, 1313, 436, 437, 1316
36, 769, 1299, 1183, 717
37, 1279, 1184, 677, 697
38, 850, 1269, 1273, 1271
39, 1124, 1196, 1323, 1329
40, 409, 408, 281, 915
41, 625, 1309, 1307, 1186
42, 1102, 1320, 1295, 1109
43, 436, 1313, 437, 1086
44, 330, 35, 995, 1243
45, 688, 93, 1203, 637
46, 652, 1241, 1166, 1233
47, 16, 431, 524, 523
48, 700, 93, 574, 1191
49, 717, 1182, 1277, 1183
50, 805, 566, 868, 1357
51, 827, 702, 472, 260
52, 523, 522, 1051, 1183
53, 1069, 185, 526, 186
54, 1286, 1287, 1282, 1075
55, 93, 1191, 1203, 635
56, 1313, 628, 1315, 1316
57, 1363, 211, 1152, 212
58, 643, 617, 1296, 629
59, 861, 1199, 869, 704
60, 89, 573, 680, 1321
61, 871, 771, 1286, 822
62, 1335, 632, 1198, 1340
63, 1148, 803, 1356, 1355
64, 1356, 1148, 1147, 373
65, 1357, 566, 868, 490
66, 1347, 1130, 1141, 443
67, 374, 1149, 1355, 1148
68, 1259, 233, 695, 671
69, 964, 929, 965, 963
70, 1266, 819, 693, 881
71, 481, 1277, 619, 480
72, 1186, 294, 1308, 1187
73, 1076, 1065, 1285, 1073
74, 618, 519, 520, 1181
75, 82, 1289, 674, 83
76, 1356, 1148, 217, 1147
77, 1270, 1269, 1271, 1178
78, 1146, 1353, 1144, 1140
79, 1148, 564, 1355, 1356
80, 1148, 803, 373, 1356
81, 1003, 991, 1235, 1237
82, 266, 1362, 113, 829
83, 1148, 803, 374, 373
84, 1186, 294, 720, 1308
85, 1124, 1127, 1329, 1323
86, 472, 827, 473, 708
87, 1067, 1271, 775, 39
88, 956, 940, 968, 949
89, 1051, 431, 183, 523
90, 1357, 1150, 1149, 375
91, 1267, 1265, 1268, 1266
92, 59, 57, 962, 961
93, 1257, 1015, 424, 1014
94, 1299, 1278, 579, 1279
95, 859, 867, 1299, 1296
96, 1201, 584, 462, 2
97, 1177, 673, 456, 1185
98, 1296, 867, 853, 859
99, 1257, 1014, 1173, 1015
100, 1333, 132, 1308, 932
101, 1201, 2, 462, 689
102, 1313, 1093, 1085, 1310
103, 948, 932, 955, 939
104, 961, 943, 962, 59
105, 1315, 245, 825, 683
106, 1313, 628, 627, 1315
107, 628, 1313, 627, 535
108, 1117, 364, 1118, 1339
109, 133, 292, 293, 930
110, 640, 1315, 628, 1316
111, 482, 1172, 612, 1252
112, 708, 485, 282, 599
113, 669, 230, 1263, 668
114, 717, 1188, 292, 718
115, 534, 1307, 1311, 626
116, 534, 1307, 1088, 1311
117, 535, 1313, 437, 628
118, 465, 104, 275, 103
119, 1186, 626, 1189, 1311
120, 534, 1189, 626, 1311
121, 640, 1315, 582, 628
122, 679, 459, 1190, 1322
123, 647, 1338, 660, 477
124, 78, 669, 670, 453
125, 814, 445, 1204, 560
126, 1158, 283, 844, 1160
127, 436, 1313, 1086, 1085
128, 1156, 495, 1216, 1213
129, 1321, 1096, 1111, 1108
130, 268, 559, 814, 560
131, 1257, 1014, 424, 1256
132, 541, 1295, 1322, 1103
133, 375, 1150, 805, 1357
134, 725, 705, 597, 726
135, 265, 466, 1363, 829
136, 1090, 776, 1297, 432
137, 126, 702, 125, 259
138, 805, 1150, 376, 1358
139, 1275, 1274, 638, 1174
140, 1156, 495, 604, 1216
141, 1296, 1300, 629, 1295
142, 837, 1174, 1260, 1176
143, 1257, 1256, 1173, 1014
144, 1296, 629, 1301, 1295
145, 1149, 804, 1355, 1357
146, 408, 409, 281, 29
147, 1150, 1358, 220, 446
148, 50, 384, 63, 898
149, 361, 43, 788, 1125
150, 441, 1120, 1119, 1341
151, 1150, 1357, 566, 805
152, 141, 302, 303, 274
153, 61, 60, 62, 959
154, 439, 1351, 1137, 1325
155, 1327, 799, 1352, 1137
156, 1257, 1258, 1176, 1256
157, 1150, 1357, 219, 566
158, 838, 247, 688, 1350
159, 1143, 1348, 1346, 1133
160, 1180, 1181, 766, 715
161, 1149, 565, 1357, 1355
162, 31, 148, 310, 733
163, 1148, 218, 1149, 1355
164, 1334, 1127, 1122, 1129
165, 1320, 1101, 1319, 1111
166, 478, 1333, 649, 589
167, 1198, 647, 631, 1195
168, 1314, 582, 1324, 1315
169, 1193, 875, 1332, 1192
170, 1307, 192, 1088, 1078
171, 1147, 467, 701, 1354
172, 1333, 132, 478, 1308
173, 1216, 1213, 495, 971
174, 467, 802, 1147, 701
175, 1349, 841, 838, 798
176, 790, 1332, 722, 1331
177, 1354, 22, 209, 444
178, 1363, 1151, 379, 1152
179, 808, 447, 1361, 1359
180, 1069, 186, 526, 1283
181, 1328, 1308, 639, 1189
182, 1198, 1335, 1340, 1126
183, 1278, 431, 523, 1281
184, 969, 941, 967, 968
185, 413, 412, 919, 897
186, 273, 142, 304, 303
187, 160, 1216, 971, 980
188, 414, 415, 1206, 1210
189, 152, 276, 105, 832
190, 1328, 1314, 656, 1205
191, 548, 1342, 634, 547
192, 1335, 632, 631, 1198
193, 1276, 1180, 715, 1181
194, 574, 656, 1324, 636
195, 413, 387, 290, 30
196, 390, 410, 953, 411
197, 142, 273, 304, 729
198, 625, 1186, 626, 1308
199, 395, 59, 962, 943
200, 160, 1216, 495, 971
201, 669, 1263, 77, 668
202, 630, 1335, 1192, 1334
203, 509, 1252, 1170, 1254
204, 75, 1266, 667, 452
205, 59, 952, 961, 927
206, 834, 8, 489, 731
207, 731, 8, 32, 834
208, 783, 1098, 356, 1107
209, 1316, 1097, 436, 1106
210, 926, 903, 924, 912
211, 1349, 797, 838, 1350
212, 484, 282, 283, 917
213, 386, 385, 407, 888
214, 1274, 714, 1275, 854
215, 1348, 865, 795, 796
216, 447, 562, 1359, 215
217, 1257, 1176, 1173, 1256
218, 160, 1216, 496, 495
219, 160, 1216, 980, 496
220, 709, 599, 473, 708
221, 1247, 1033, 422, 421
222, 1134, 1348, 1202, 1142
223, 1348, 1202, 550, 685
224, 819, 881, 1171, 849
225, 706, 727, 465, 728
226, 1310, 1084, 1085, 1313
227, 1142, 1348, 1202, 1139
228, 915, 485, 281, 138
229, 888, 383, 913, 406
230, 248, 797, 796, 1202
231, 1313, 1311, 1310, 1189
232, 406, 405, 51, 400
233, 540, 1322, 198, 541
234, 1201, 865, 25, 862
235, 831, 487, 729, 272
236, 1313, 1093, 1086, 1085
237, 1293, 1270, 428, 1178
238, 1347, 1201, 1346, 1348
239, 560, 445, 1154, 814
240, 599, 588, 473, 708
241, 68, 406, 51, 400
242, 1032, 1268, 1040, 1265
243, 874, 1305, 1306, 719
244, 45, 371, 800, 1204
245, 1025, 1038, 1267, 668
246, 517, 1268, 1171, 577
247, 1250, 1009, 1249, 1021
248, 801, 27, 1204, 4
249, 159, 416, 971, 1213
250, 1220, 606, 1225, 1161
251, 577, 1171, 517, 641
252, 606, 1220, 645, 1224
253, 1310, 1084, 1083, 1085
254, 669, 694, 670, 1263
255, 1315, 92, 683, 461
256, 961, 943, 59, 928
257, 1220, 711, 1223, 1224
258, 302, 139, 728, 140
259, 1328, 1314, 1189, 656
260, 1362, 1363, 811, 1152
261, 1313, 1315, 1314, 883
262, 1212, 282, 599, 709
263, 1315, 857, 1316, 825
264, 618, 1179, 1181, 1274
265, 781, 1310, 1313, 1084
266, 1362, 1153, 212, 1152
267, 1329, 1328, 1193, 1334
268, 1302, 1090, 776, 1297
269, 728, 465, 103, 140
270, 1315, 825, 1316, 683
271, 255, 155, 121, 120
272, 1006, 1168, 1021, 1016
273, 431, 430, 1278, 1051
274, 1290, 1283, 1061, 1284
275, 1290, 1292, 1185, 1288
276, 1313, 628, 1316, 437
277, 1314, 1315, 1313, 627
278, 930, 947, 954, 294
279, 918, 911, 923, 893
280, 1338, 131, 937, 477
281, 353, 779, 1082, 778
282, 874, 1305, 719, 778
283, 1189, 1314, 1313, 627
284, 828, 262, 1155, 26
285, 963, 953, 943, 928
286, 1326, 1327, 1205, 1325
287, 793, 860, 1341, 792
288, 534, 1189, 1313, 627
289, 640, 1315, 461, 582
290, 467, 802, 563, 1147
291, 1202, 1131, 1139, 550
292, 1356, 802, 1147, 563
293, 551, 1131, 1202, 550
294, 973, 1210, 986, 982
295, 1266, 229, 693, 228
296, 1316, 640, 536, 628
297, 1215, 974, 322, 741
298, 993, 749, 1239, 1236
299, 168, 1246, 1244, 997
300, 986, 974, 1211, 983
301, 1259, 80, 671, 455
302, 1215, 1211, 741, 1158
303, 983, 740, 1211, 1210
304, 485, 137, 138, 915
305, 983, 1210, 1211, 986
306, 535, 1086, 437, 1313
307, 913, 887, 888, 921
308, 1156, 986, 1211, 1210
309, 545, 1113, 202, 1340
310, 193, 534, 1088, 1086
311, 1215, 1211, 974, 741
312, 438, 1326, 1125, 1114
313, 28, 280, 807, 1360
314, 534, 535, 627, 1313
315, 1260, 644, 1275, 1269
316, 114, 813, 830, 267
317, 737, 738, 10, 491
318, 1247, 849, 752, 851
319, 817, 223, 664, 224
320, 640, 1315, 1316, 461
321, 290, 919, 289, 897
322, 999, 168, 1244, 997
323, 724, 463, 704, 598
324, 1003, 988, 1241, 998
325, 385, 914, 407, 888
326, 939, 932, 940, 948
327, 827, 703, 473, 708
328, 114, 813, 583, 830
329, 1278, 429, 1280, 769
330, 178, 1033, 422, 517
331, 919, 907, 891, 901
332, 848, 1227, 1231, 1163
333, 1238, 1235, 1241, 1003
334, 1017, 510, 1254, 1255
335, 1217, 1214, 984, 1221
336, 1035, 1268, 1267, 1038
337, 1028, 760, 338, 1029
338, 1290, 1283, 527, 1061
339, 31, 148, 733, 7
340, 246, 1203, 841, 838
341, 1248, 1247, 752, 851
342, 1021, 1249, 1250, 1168
343, 1315, 683, 1316, 461
344, 864, 588, 472, 587
345, 1316, 682, 1318, 460
346, 1207, 494, 1159, 1246
347, 1275, 850, 837, 1269
348, 1198, 660, 1338, 1336
349, 25, 861, 704, 1201
350, 1362, 113, 829, 466
351, 1265, 881, 762, 763
352, 471, 864, 472, 587
353, 1314, 582, 656, 1324
354, 1277, 619, 480, 620
355, 588, 864, 707, 587
356, 1238, 1240, 989, 503
357, 607, 498, 1220, 645
358, 36, 1231, 746, 1001
359, 774, 1067, 1291, 775
360, 228, 229, 667, 1266
361, 640, 461, 1316, 460
362, 25, 1201, 862, 861
363, 658, 1224, 1220, 1223
364, 658, 1224, 645, 1220
365, 655, 529, 1292, 528
366, 922, 285, 890, 917
367, 517, 641, 1171, 1247
368, 232, 695, 1175, 820
369, 1243, 35, 751, 330
370, 1167, 222, 843, 26
371, 1102, 787, 360, 41
372, 1247, 641, 616, 517
373, 1293, 1178, 1269, 1270
374, 377, 215, 1359, 1358
375, 1293, 1068, 428, 1270
376, 683, 460, 1316, 461
377, 536, 437, 1316, 628
378, 1196, 1323, 1205, 1325
379, 437, 1316, 1106, 1095
380, 1293, 1178, 428, 1272
381, 1293, 1272, 1269, 1178
382, 1156, 1158, 1212, 833
383, 1200, 443, 1344, 1347
384, 859, 776, 853, 1298
385, 470, 306, 145, 732
386, 437, 1106, 1316, 436
387, 958, 933, 950, 385
388, 31, 139, 727, 301
389, 1084, 1085, 1313, 435
390, 728, 465, 275, 103
391, 681, 784, 1319, 242
392, 1238, 70, 664, 1240
393, 1317, 781, 1313, 435
394, 1198, 791, 1339, 723
395, 1156, 1157, 1211, 833
396, 731, 471, 702, 470
397, 805, 566, 840, 868
398, 156, 119, 253, 157
399, 470, 306, 144, 145
400, 124, 732, 125, 470
401, 1157, 1156, 1212, 833
402, 435, 1085, 1313, 436
403, 380, 379, 1152, 811
404, 781, 1084, 1313, 435
405, 167, 1240, 989, 999
406, 815, 738, 733, 492
407, 1293, 1272, 428, 518
408, 1182, 522, 1053, 521
409, 797, 1135, 796, 1202
410, 1293, 644, 1269, 1272
411, 509, 1252, 612, 1170
412, 482, 592, 134, 916
413, 1054, 1179, 1042, 1272
414, 797, 368, 796, 1135
415, 167, 1240, 503, 989
416, 969, 970, 963, 939
417, 600, 486, 29, 707
418, 1244, 1246, 1155, 1245
419, 1338, 297, 1333, 1195
420, 376, 375, 1150, 805
421, 856, 845, 1314, 1189
422, 1082, 719, 1305, 778
423, 544, 630, 543, 1334
424, 712, 1170, 1172, 288
425, 1188, 650, 1299, 648
426, 1149, 804, 374, 1355
427, 588, 485, 486, 281
428, 24, 567, 561, 1358
429, 284, 917, 283, 899
430, 3, 562, 1360, 1361
431, 1149, 804, 375, 374
432, 390, 397, 942, 410
433, 808, 28, 807, 1360
434, 109, 567, 1358, 561
435, 1338, 299, 477, 937
436, 1265, 339, 1030, 340
437, 1238, 70, 569, 664
438, 1160, 1216, 604, 605
439, 1149, 804, 1357, 375
440, 1208, 842, 1155, 1207
441, 1221, 984, 987, 976
442, 850, 764, 1271, 1273
443, 1120, 1194, 1341, 1343
444, 409, 300, 931, 129
445, 1358, 215, 446, 377
446, 1148, 803, 1355, 374
447, 1250, 1009, 873, 1249
448, 1259, 233, 821, 695
449, 1187, 133, 932, 132
450, 1167, 1002, 1004, 994
451, 1338, 654, 299, 1336
452, 802, 1356, 1147, 373
453, 280, 1358, 807, 1360
454, 483, 1224, 645, 593
455, 373, 372, 1147, 802
456, 511, 510, 1255, 614
457, 283, 284, 844, 1160
458, 372, 701, 1147, 802
459, 694, 669, 230, 1263
460, 1208, 842, 828, 1155
461, 1210, 1159, 1206, 1207
462, 24, 215, 1358, 561
463, 1158, 1160, 844, 1215
464, 56, 903, 904, 54
465, 844, 1214, 1215, 1160
466, 974, 835, 1211, 983
467, 1157, 709, 828, 833
468, 79, 1175, 670, 671
469, 1175, 232, 670, 671
470, 882, 1107, 782, 1317
471, 1032, 1265, 1030, 1031
472, 444, 1354, 1147, 372
473, 463, 269, 704, 462
474, 1202, 551, 550, 95
475, 1170, 755, 1011, 1253
476, 573, 540, 459, 1322
477, 1201, 865, 221, 25
478, 372, 1354, 1147, 701
479, 1155, 1208, 1207, 609
480, 967, 938, 952, 960
481, 929, 963, 945, 965
482, 1316, 682, 699, 1318
483, 412, 893, 897, 388
484, 1199, 1201, 462, 704
485, 1265, 1032, 763, 1031
486, 482, 922, 287, 916
487, 710, 1219, 743, 1214
488, 717, 648, 1277, 1188
489, 763, 1265, 1031, 340
490, 566, 868, 568, 840
491, 844, 710, 1214, 1160
492, 1352, 798, 1349, 370
493, 925, 889, 917, 899
494, 1320, 1109, 1111, 1322
495, 1241, 501, 502, 165
496, 544, 545, 631, 1335
497, 905, 926, 895, 910
498, 1179, 854, 1275, 1273
499, 176, 175, 1034, 514
500, 709, 1157, 1212, 833
501, 108, 568, 279, 840
502, 702, 471, 878, 864
503, 742, 1215, 844, 1214
504, 1215, 1211, 986, 974
505, 1150, 1358, 566, 220
506, 808, 1359, 807, 377
507, 969, 940, 948, 939
508, 1150, 1357, 1149, 219
509, 219, 220, 1150, 566
510, 617, 1296, 1294, 1299
511, 1149, 565, 219, 1357
512, 215, 1359, 447, 377
513, 1149, 565, 218, 219
514, 705, 464, 99, 575
515, 1356, 373, 802, 803
516, 739, 1356, 802, 803
517, 568, 735, 279, 840
518, 1267, 515, 1025, 668
519, 1348, 795, 1346, 1133
520, 64, 56, 394, 391
521, 1265, 229, 761, 693
522, 868, 735, 568, 840
523, 1149, 565, 1355, 218
524, 1003, 1238, 998, 1241
525, 1148, 564, 218, 1355
526, 1148, 564, 217, 218
527, 1148, 564, 1356, 217
528, 1241, 501, 569, 502
529, 1060, 431, 1071, 1281
530, 1069, 1287, 1060, 1075
531, 1039, 1026, 1037, 1262
532, 865, 1346, 1201, 1348
533, 167, 1240, 504, 503
534, 1265, 881, 693, 762
535, 865, 1346, 862, 1201
536, 917, 889, 915, 282
537, 1141, 1130, 1347, 1348
538, 1175, 615, 455, 454
539, 513, 1034, 1264, 1024
540, 1132, 1143, 1346, 1133
541, 1345, 794, 862, 861
542, 794, 1345, 862, 795
543, 686, 1165, 1171, 451
544, 336, 38, 758, 1037
545, 682, 538, 1318, 460
546, 197, 1105, 539, 1096
547, 1224, 642, 1251, 1223
548, 444, 216, 1147, 1354
549, 1017, 510, 172, 1254
550, 217, 1356, 1147, 563
551, 243, 244, 682, 699
552, 1279, 823, 697, 239
553, 412, 944, 413, 930
554, 1104, 539, 1096, 196
555, 531, 1077, 1303, 530
556, 1077, 1303, 1301, 1089
557, 783, 1316, 1318, 1107
558, 217, 563, 1147, 216
559, 1321, 573, 539, 89
560, 1118, 1197, 792, 1341
561, 1238, 569, 1241, 664
562, 79, 1175, 671, 455
563, 296, 295, 1333, 1328
564, 1147, 467, 216, 563
565, 1147, 467, 1354, 216
566, 1021, 1019, 1249, 1248
567, 276, 104, 275, 706
568, 141, 274, 303, 273
569, 273, 274, 102, 141
570, 475, 300, 726, 29
571, 1352, 798, 841, 1349
572, 600, 475, 726, 29
573, 475, 300, 597, 726
574, 114, 813, 559, 583
575, 1347, 1348, 1346, 1141
576, 1296, 643, 629, 1300
577, 600, 475, 597, 726
578, 491, 706, 601, 737
579, 215, 24, 1358, 446
580, 1344, 1199, 1343, 1200
581, 97, 269, 462, 689
582, 634, 1344, 1337, 1342
583, 706, 736, 601, 737
584, 491, 153, 737, 601
585, 149, 9, 734, 490
586, 258, 732, 124, 145
587, 1248, 1019, 1008, 1021
588, 1217, 1214, 1215, 984
589, 815, 317, 316, 155
590, 663, 1167, 690, 1239
591, 661, 1275, 638, 1174
592, 1050, 430, 1051, 1278
593, 1291, 1177, 1292, 1185
594, 126, 471, 125, 702
595, 470, 306, 731, 144
596, 1239, 1167, 690, 750
597, 753, 331, 1009, 332
598, 712, 1251, 873, 287
599, 738, 815, 316, 154
600, 144, 489, 731, 470
601, 1177, 655, 1292, 1185
602, 1290, 1292, 528, 1185
603, 815, 155, 316, 154
604, 710, 742, 844, 1214
605, 1292, 1288, 1291, 1185
606, 925, 922, 890, 917
607, 223, 1239, 663, 690
608, 730, 32, 143, 488
609, 930, 947, 932, 939
610, 584, 1347, 1201, 1199
611, 305, 304, 729, 143
612, 729, 142, 487, 143
613, 148, 826, 310, 733
614, 893, 918, 411, 923
615, 972, 981, 162, 1225
616, 820, 694, 759, 1262
617, 815, 826, 469, 492
618, 999, 1167, 1004, 1244
619, 1206, 1210, 740, 414
620, 729, 142, 101, 487
621, 904, 56, 54, 391
622, 900, 925, 909, 891
623, 1238, 569, 503, 502
624, 1187, 293, 719, 294
625, 670, 694, 1262, 1263
626, 729, 273, 101, 142
627, 416, 1159, 415, 982
628, 1029, 1263, 668, 1041
629, 729, 730, 143, 487
630, 581, 600, 726, 846
631, 759, 1037, 758, 1262
632, 917, 282, 137, 484
633, 1167, 222, 1, 69
634, 1235, 691, 747, 748
635, 694, 820, 670, 1262
636, 474, 262, 128, 1
637, 581, 705, 575, 464
638, 273, 142, 141, 101
639, 149, 568, 490, 734
640, 746, 36, 1001, 326
641, 729, 142, 143, 304
642, 1236, 749, 328, 993
643, 273, 142, 303, 141
644, 1238, 1235, 664, 1241
645, 504, 1167, 596, 448
646, 284, 1160, 285, 710
647, 962, 399, 67, 66
648, 49, 56, 912, 55
649, 314, 153, 736, 315
650, 59, 952, 57, 961
651, 959, 938, 58, 60
652, 1027, 760, 1263, 759
653, 885, 1162, 744, 884
654, 938, 952, 58, 60
655, 928, 936, 943, 59
656, 496, 980, 161, 1218
657, 974, 1215, 975, 986
658, 936, 395, 943, 59
659, 1238, 1235, 1236, 664
660, 1162, 1219, 744, 884
661, 1238, 502, 1241, 569
662, 986, 1217, 980, 1216
663, 666, 72, 450, 73
664, 419, 500, 1230, 1233
665, 339, 761, 1029, 338
666, 346, 771, 1072, 770
667, 999, 1004, 997, 1244
668, 496, 1218, 161, 497
669, 606, 1160, 1161, 483
670, 927, 928, 961, 59
671, 395, 66, 962, 59
672, 482, 922, 1251, 287
673, 880, 1256, 1173, 1176
674, 1247, 1268, 1171, 517
675, 960, 959, 938, 58
676, 522, 1051, 1183, 1053
677, 431, 16, 183, 523
678, 1114, 1326, 1125, 1330
679, 1019, 1248, 752, 1249
680, 1317, 42, 782, 781
681, 618, 1179, 519, 1181
682, 713, 1174, 289, 714
683, 952, 960, 938, 58
684, 1291, 775, 1271, 850
685, 820, 758, 1262, 759
686, 300, 299, 931, 476
687, 435, 42, 781, 1084
688, 955, 295, 932, 296
689, 1284, 1069, 1282, 1283
690, 18, 194, 536, 437
691, 1310, 855, 1312, 780
692, 1265, 229, 668, 761
693, 925, 923, 910, 909
694, 923, 907, 910, 909
695, 85, 1184, 458, 457
696, 481, 30, 290, 1276
697, 676, 237, 1286, 1282
698, 959, 61, 60, 58
699, 1216, 496, 604, 605
700, 58, 60, 952, 57
701, 724, 704, 1337, 598
702, 1187, 1294, 1306, 1188
703, 366, 1346, 795, 1133
704, 232, 820, 670, 231
705, 1260, 644, 661, 1275
706, 1290, 1292, 1070, 528
707, 200, 544, 1122, 201
708, 59, 952, 60, 57
709, 716, 1182, 768, 767
710, 66, 67, 962, 57
711, 1342, 1194, 1337, 1197
712, 1056, 1058, 1053, 1182
713, 66, 57, 962, 59
714, 1347, 204, 549, 1130
715, 1186, 294, 719, 720
716, 959, 401, 62, 404
717, 614, 1255, 1174, 613
718, 619, 618, 1276, 481
719, 59, 952, 927, 60
720, 1169, 662, 1247, 1223
721, 1255, 1174, 613, 1254
722, 1329, 636, 1205, 624
723, 1363, 379, 811, 1152
724, 447, 562, 1361, 1359
725, 1236, 749, 817, 748
726, 656, 636, 624, 1205
727, 738, 737, 10, 34
728, 316, 738, 154, 34
729, 801, 46, 1354, 371
730, 514, 1041, 1263, 1034
731, 834, 488, 8, 32
732, 1236, 664, 1235, 817
733, 1238, 166, 989, 998
734, 1329, 636, 1196, 1205
735, 717, 1182, 716, 1277
736, 625, 1307, 626, 1186
737, 1186, 626, 1308, 1189
738, 773, 696, 774, 1288
739, 730, 32, 305, 143
740, 1177, 673, 672, 456
741, 773, 1065, 348, 1285
742, 859, 718, 777, 1294
743, 639, 651, 1189, 626
744, 778, 719, 779, 1082
745, 633, 1342, 547, 634
746, 937, 298, 956, 297
747, 491, 492, 738, 10
748, 1259, 233, 672, 821
749, 153, 491, 737, 10
750, 34, 10, 738, 154
751, 295, 720, 1308, 1189
752, 963, 927, 928, 961
753, 492, 154, 738, 10
754, 95, 685, 96, 550
755, 1182, 716, 1180, 767
756, 856, 1313, 1314, 883
757, 78, 669, 453, 77
758, 700, 93, 245, 574
759, 1322, 1319, 1321, 1111
760, 34, 153, 737, 10
761, 1315, 245, 700, 825
762, 1324, 574, 1191, 700
763, 488, 489, 834, 8
764, 1186, 720, 1189, 1308
765, 489, 144, 731, 8
766, 43, 1326, 788, 1125
767, 143, 488, 32, 8
768, 584, 1201, 580, 2
769, 889, 925, 917, 915
770, 144, 32, 731, 8
771, 869, 1341, 860, 1337
772, 1327, 788, 1326, 1205
773, 1329, 440, 1196, 542
774, 947, 930, 964, 939
775, 147, 308, 257, 123
776, 790, 1116, 363, 362
777, 720, 1310, 1189, 856
778, 209, 371, 1354, 444
779, 720, 1310, 1186, 1189
780, 27, 560, 814, 1204
781, 559, 813, 558, 583
782, 537, 1316, 1095, 1318
783, 1350, 688, 1203, 637
784, 114, 813, 267, 559
785, 1238, 998, 1241, 502
786, 869, 1341, 793, 860
787, 27, 560, 268, 814
788, 515, 1267, 76, 668
789, 1199, 1346, 1201, 1345
790, 812, 830, 829, 1362
791, 1334, 1332, 1129, 1192
792, 633, 1197, 1342, 1337
793, 1362, 830, 266, 583
794, 258, 732, 125, 124
795, 652, 1164, 1233, 1166
796, 911, 926, 924, 923
797, 1315, 883, 825, 700
798, 1200, 442, 1343, 1344
799, 857, 883, 825, 1315
800, 1138, 1351, 553, 1353
801, 814, 45, 800, 1204
802, 1349, 841, 1203, 838
803, 911, 907, 910, 923
804, 215, 1359, 1358, 561
805, 840, 109, 567, 1358
806, 447, 562, 23, 1361
807, 958, 408, 409, 934
808, 1153, 812, 813, 381
809, 712, 1251, 1250, 873
810, 1220, 711, 876, 1223
811, 1238, 166, 503, 989
812, 1313, 857, 883, 781
813, 1225, 1220, 1162, 1228
814, 1226, 885, 1162, 744
815, 1276, 1277, 619, 481
816, 236, 772, 1285, 773
817, 177, 1035, 1267, 1025
818, 1264, 1039, 1034, 1263
819, 934, 949, 957, 966
820, 686, 1165, 819, 1171
821, 1247, 752, 849, 763
822, 837, 714, 1275, 1174
823, 606, 1220, 498, 645
824, 1274, 714, 715, 290
825, 300, 475, 597, 476
826, 921, 898, 913, 887
827, 1220, 711, 836, 876
828, 1220, 711, 1224, 836
829, 654, 724, 598, 653
830, 1204, 371, 1354, 209
831, 1101, 786, 1320, 1319
832, 109, 1360, 561, 1358
833, 1356, 493, 564, 1355
834, 395, 398, 943, 399
835, 1258, 1262, 1261, 1175
836, 424, 1258, 1256, 423
837, 486, 281, 29, 707
838, 880, 1256, 757, 1173
839, 408, 958, 409, 29
840, 1243, 842, 1207, 1155
841, 486, 409, 29, 281
842, 121, 815, 256, 469
843, 695, 1259, 1175, 847
844, 1243, 842, 740, 1207
845, 370, 1349, 1352, 1137
846, 1315, 245, 574, 700
847, 314, 153, 152, 736
848, 838, 1203, 688, 246
849, 1261, 512, 615, 454
850, 9, 149, 734, 33
851, 914, 925, 926, 905
852, 85, 1184, 457, 676
853, 691, 1235, 817, 748
854, 27, 801, 1204, 800
855, 1191, 841, 858, 700
856, 1186, 720, 719, 855
857, 1237, 326, 746, 1001
858, 602, 1208, 1207, 1157
859, 490, 734, 1357, 1355
860, 155, 492, 815, 469
861, 995, 330, 1243, 994
862, 858, 1324, 700, 870
863, 858, 1324, 1191, 700
864, 1032, 420, 763, 1031
865, 804, 375, 805, 1357
866, 1251, 1250, 1168, 1172
867, 1328, 295, 721, 296
868, 1258, 820, 1262, 1175
869, 1227, 876, 866, 1222
870, 646, 1156, 1212, 1157
871, 1159, 1210, 1206, 415
872, 508, 1007, 509, 1170
873, 1175, 1261, 615, 454
874, 1057, 1273, 1045, 1179
875, 152, 276, 601, 104
876, 1048, 345, 1049, 769
877, 1157, 586, 646, 602
878, 1277, 6, 133, 480
879, 1043, 181, 1052, 520
880, 893, 918, 894, 389
881, 1336, 724, 1337, 598
882, 1194, 1343, 1337, 1341
883, 1262, 1036, 1261, 1264
884, 1153, 812, 380, 1362
885, 47, 446, 377, 1358
886, 1176, 1174, 880, 837
887, 792, 1119, 1118, 1341
888, 786, 1101, 360, 359
889, 1, 1155, 474, 262
890, 683, 460, 461, 91
891, 1257, 614, 1255, 1174
892, 608, 1230, 1227, 607
893, 1090, 776, 432, 41
894, 357, 1098, 356, 783
895, 550, 1130, 1348, 549
896, 776, 1090, 351, 41
897, 222, 1167, 663, 69
898, 1352, 798, 799, 841
899, 1174, 756, 1173, 880
900, 874, 1306, 293, 719
901, 1297, 787, 1295, 432
902, 47, 377, 807, 1358
903, 1329, 1205, 1196, 1323
904, 898, 49, 902, 55
905, 1323, 1326, 1205, 1325
906, 1361, 808, 1360, 28
907, 300, 475, 476, 129
908, 447, 1151, 378, 1361
909, 1036, 424, 1026, 1258
910, 152, 104, 105, 276
911, 770, 429, 769, 1280
912, 1063, 772, 1064, 1286
913, 1185, 655, 1292, 528
914, 30, 715, 1180, 716
915, 1258, 758, 847, 1256
916, 570, 1269, 1259, 1177
917, 1260, 661, 1174, 1275
918, 1200, 1345, 1346, 1199
919, 942, 953, 928, 943
920, 1318, 783, 1098, 1099
921, 1287, 676, 675, 84
922, 330, 750, 1243, 994
923, 837, 1176, 1260, 1259
924, 566, 1357, 565, 490
925, 770, 429, 40, 769
926, 148, 7, 492, 733
927, 1174, 756, 713, 1253
928, 1251, 1250, 873, 1249
929, 1257, 614, 511, 1255
930, 933, 958, 950, 957
931, 676, 1287, 675, 1282
932, 254, 155, 317, 255
933, 586, 1157, 646, 1212
934, 815, 155, 255, 317
935, 1248, 420, 752, 1247
936, 1013, 756, 757, 1173
937, 581, 872, 594, 657
938, 581, 846, 872, 657
939, 914, 408, 915, 896
940, 402, 383, 913, 384
941, 866, 578, 1222, 1247
942, 487, 464, 730, 488
943, 205, 1139, 206, 550
944, 912, 55, 921, 902
945, 1309, 1091, 1078, 1307
946, 406, 407, 921, 888
947, 913, 406, 921, 888
948, 398, 936, 943, 942
949, 491, 727, 737, 733
950, 420, 1032, 1247, 421
951, 692, 1227, 866, 1165
952, 423, 1258, 1026, 424
953, 1248, 1223, 1169, 1247
954, 1351, 1137, 1325, 1352
955, 866, 578, 1227, 1222
956, 837, 713, 714, 1174
957, 831, 581, 872, 594
958, 256, 122, 121, 469
959, 288, 289, 1252, 916
960, 491, 738, 492, 733
961, 837, 1174, 880, 713
962, 1250, 1009, 1010, 873
963, 941, 967, 927, 939
964, 967, 963, 927, 939
965, 397, 65, 396, 410
966, 886, 1210, 1157, 1211
967, 1262, 1264, 670, 1263
968, 1027, 760, 1028, 1263
969, 772, 1064, 1282, 1285
970, 1007, 1017, 1254, 1020
971, 776, 787, 432, 41
972, 1169, 662, 616, 1247
973, 955, 947, 970, 939
974, 626, 625, 1308, 590
975, 769, 345, 768, 1048
976, 361, 1125, 788, 1330
977, 1138, 1351, 1196, 553
978, 1351, 1191, 1352, 1325
979, 523, 522, 183, 1051
980, 944, 412, 945, 965
981, 1261, 511, 425, 1257
982, 199, 1329, 440, 1112
983, 1040, 1032, 1265, 1030
984, 793, 869, 1345, 1341
985, 784, 1100, 1108, 1319
986, 879, 1226, 1222, 1163
987, 964, 929, 963, 939
988, 824, 679, 698, 1319
989, 43, 1326, 1327, 788
990, 1021, 1018, 1008, 1248
991, 1247, 1171, 866, 1165
992, 779, 353, 1082, 354
993, 141, 103, 274, 102
994, 1353, 208, 1140, 552
995, 22, 1354, 209, 576
996, 1220, 1222, 1162, 1228
997, 1227, 607, 578, 608
998, 156, 317, 318, 254
999, 464, 705, 271, 831
1000, 951, 938, 935, 950
1001, 911, 918, 923, 924
1002, 440, 553, 1138, 1196
1003, 930, 292, 293, 946
1004, 1321, 1319, 681, 1108
1005, 1064, 1282, 1075, 1286
1006, 1329, 440, 1124, 1196
1007, 1289, 1283, 1284, 1282
1008, 1201, 1347, 580, 1348
1009, 759, 1037, 336, 758
1010, 938, 933, 935, 950
1011, 960, 933, 950, 966
1012, 306, 145, 732, 307
1013, 153, 152, 736, 601
1014, 276, 706, 736, 601
1015, 938, 951, 960, 950
1016, 276, 104, 706, 601
1017, 465, 706, 601, 491
1018, 860, 1197, 1341, 792
1019, 1344, 1199, 1337, 1343
1020, 953, 410, 928, 411
1021, 793, 441, 1119, 1341
1022, 1282, 1283, 675, 1289
1023, 1142, 1131, 1139, 1202
1024, 918, 390, 389, 411
1025, 831, 100, 487, 272
1026, 1299, 1278, 1183, 579
1027, 106, 152, 105, 832
1028, 765, 1181, 715, 766
1029, 914, 408, 896, 385
1030, 412, 944, 930, 965
1031, 831, 872, 730, 594
1032, 876, 1223, 866, 1222
1033, 1223, 1247, 866, 1222
1034, 210, 447, 1361, 1151
1035, 145, 258, 308, 146
1036, 1355, 734, 9, 490
1037, 1220, 658, 607, 645
1038, 497, 1218, 972, 1225
1039, 1251, 1249, 1168, 1250
1040, 665, 664, 1235, 1241
1041, 483, 1160, 484, 605
1042, 145, 732, 307, 258
1043, 1032, 1268, 1033, 1040
1044, 1266, 228, 686, 667
1045, 1240, 1236, 1005, 1239
1046, 406, 951, 386, 405
1047, 930, 947, 964, 954
1048, 1238, 1235, 1003, 1236
1049, 848, 1164, 692, 818
1050, 1164, 226, 1165, 692
1051, 511, 1255, 1015, 1257
1052, 747, 1235, 1237, 818
1053, 177, 515, 176, 1025
1054, 1050, 769, 1183, 1048
1055, 953, 929, 411, 928
1056, 1254, 1007, 509, 172
1057, 681, 243, 1318, 784
1058, 1228, 607, 498, 1220
1059, 1261, 511, 512, 425
1060, 981, 1228, 498, 1225
1061, 1322, 680, 1321, 1319
1062, 1254, 1017, 1007, 172
1063, 287, 711, 1251, 873
1064, 401, 951, 959, 935
1065, 584, 1347, 549, 580
1066, 60, 401, 959, 935
1067, 1347, 204, 548, 549
1068, 1351, 635, 1353, 1203
1069, 1335, 632, 545, 631
1070, 772, 347, 1064, 348
1071, 1363, 1151, 810, 379
1072, 406, 951, 935, 386
1073, 21, 1204, 554, 209
1074, 1228, 1222, 607, 1220
1075, 595, 650, 531, 1294
1076, 1164, 848, 1227, 1231
1077, 1279, 1184, 458, 677
1078, 1046, 342, 766, 1045
1079, 1294, 595, 1304, 531
1080, 782, 42, 1107, 356
1081, 1228, 1230, 1229, 979
1082, 783, 699, 1318, 1316
1083, 786, 698, 1320, 1319
1084, 1094, 1087, 1304, 1309
1085, 1249, 1251, 1223, 711
1086, 419, 1232, 418, 1000
1087, 391, 904, 920, 894
1088, 1087, 1094, 1078, 1309
1089, 1163, 417, 978, 418
1090, 100, 464, 99, 271
1091, 907, 919, 891, 909
1092, 589, 1195, 1333, 649
1093, 948, 937, 940, 956
1094, 1229, 1227, 1230, 1222
1095, 1200, 1345, 1132, 1346
1096, 1347, 204, 443, 548
1097, 207, 551, 206, 1131
1098, 867, 823, 697, 1279
1099, 1253, 1022, 1173, 1012
1100, 1235, 665, 1241, 1166
1101, 49, 50, 63, 898
1102, 1170, 755, 754, 1011
1103, 37, 340, 763, 1031
1104, 1013, 38, 757, 335
1105, 1098, 1110, 1107, 1318
1106, 1356, 493, 563, 564
1107, 1312, 1082, 779, 719
1108, 1300, 1190, 572, 1295
1109, 1305, 874, 777, 778
1110, 1251, 1223, 1168, 1249
1111, 717, 648, 1183, 1277
1112, 1153, 1154, 558, 213
1113, 372, 1354, 46, 444
1114, 813, 583, 830, 1362
1115, 713, 1253, 877, 1252
1116, 463, 725, 575, 597
1117, 1186, 626, 1311, 1307
1118, 1238, 166, 502, 503
1119, 1293, 1068, 1270, 1292
1120, 705, 581, 597, 726
1121, 933, 407, 935, 950
1122, 801, 4, 576, 250
1123, 581, 831, 872, 726
1124, 1131, 551, 206, 550
1125, 288, 713, 877, 1252
1126, 376, 446, 47, 1358
1127, 1246, 494, 609, 1207
1128, 1305, 1306, 719, 1187
1129, 1228, 1226, 985, 1229
1130, 1234, 1232, 1164, 1233
1131, 966, 949, 940, 934
1132, 1247, 662, 616, 641
1133, 914, 407, 888, 921
1134, 933, 966, 934, 957
1135, 290, 919, 916, 289
1136, 1279, 622, 458, 1184
1137, 31, 139, 7, 727
1138, 958, 933, 934, 957
1139, 1229, 978, 1163, 1226
1140, 1338, 131, 1333, 937
1141, 299, 724, 653, 725
1142, 725, 463, 653, 597
1143, 1234, 1241, 1235, 1003
1144, 1196, 636, 553, 1191
1145, 1168, 508, 1016, 507
1146, 1233, 1164, 652, 608
1147, 848, 1164, 1227, 692
1148, 72, 449, 1166, 450
1149, 1162, 981, 987, 1225
1150, 1175, 1259, 455, 615
1151, 687, 226, 1165, 666
1152, 934, 299, 957, 949
1153, 1164, 746, 1231, 1237
1154, 644, 585, 623, 1269
1155, 745, 417, 978, 1163
1156, 299, 934, 957, 300
1157, 1090, 1079, 1302, 1092
1158, 1238, 166, 998, 502
1159, 944, 930, 965, 946
1160, 682, 538, 681, 1318
1161, 1351, 635, 1203, 1191
1162, 682, 538, 90, 681
1163, 106, 152, 832, 313
1164, 1139, 1131, 206, 550
1165, 1226, 1229, 1222, 1163
1166, 522, 182, 1053, 521
1167, 166, 502, 165, 998
1168, 666, 687, 73, 1165
1169, 985, 981, 987, 1162
1170, 366, 1346, 1345, 795
1171, 292, 413, 930, 133
1172, 710, 836, 884, 1161
1173, 13, 506, 517, 422
1174, 422, 1169, 616, 1247
1175, 795, 1133, 796, 367
1176, 204, 549, 1130, 205
1177, 1084, 42, 781, 355
1178, 795, 366, 1133, 367
1179, 419, 500, 12, 1230
1180, 1276, 1277, 1180, 619
1181, 449, 501, 569, 1241
1182, 504, 1240, 999, 1167
1183, 1167, 1002, 1239, 1240
1184, 1002, 993, 1239, 1005
1185, 1261, 511, 615, 512
1186, 1224, 642, 593, 1251
1187, 926, 912, 902, 895
1188, 893, 412, 897, 908
1189, 489, 731, 878, 834
1190, 750, 1167, 690, 843
1191, 658, 1224, 642, 645
1192, 1247, 1223, 851, 1248
1193, 1226, 978, 1163, 745
1194, 836, 1162, 1161, 1220
1195, 980, 496, 1216, 1218
1196, 457, 526, 84, 1287
1197, 1307, 192, 534, 1088
1198, 749, 1239, 817, 690
1199, 1317, 1316, 1097, 436
1200, 1251, 642, 1168, 1223
1201, 1283, 1287, 1282, 675
1202, 1312, 1311, 1186, 1310
1203, 780, 855, 856, 1310
1204, 595, 1309, 625, 1187
1205, 897, 412, 919, 908
1206, 1252, 638, 613, 592
1207, 717, 1182, 768, 716
1208, 288, 1172, 1252, 1170
1209, 1297, 776, 787, 432
1210, 1219, 1162, 987, 1225
1211, 1297, 1089, 433, 1301
1212, 650, 1188, 1299, 1294
1213, 136, 285, 917, 1160
1214, 630, 1328, 649, 624
1215, 1307, 1091, 1088, 1311
1216, 724, 654, 598, 1336
1217, 1317, 436, 1313, 1316
1218, 930, 964, 965, 954
1219, 1317, 436, 1097, 435
1220, 769, 1050, 429, 1049
1221, 1274, 765, 1181, 715
1222, 200, 1112, 1334, 543
1223, 981, 1162, 1228, 1225
1224, 236, 674, 1282, 675
1225, 776, 859, 777, 1298
1226, 1184, 457, 622, 458
1227, 467, 802, 816, 563
1228, 237, 772, 1286, 1282
1229, 1349, 798, 1136, 370
1230, 963, 929, 928, 927
1231, 462, 1199, 704, 1337
1232, 1199, 1347, 548, 584
1233, 1195, 1331, 1198, 722
1234, 1247, 1171, 849, 866
1235, 1064, 1285, 1073, 1282
1236, 710, 836, 1161, 285
1237, 1113, 545, 202, 201
1238, 794, 1345, 795, 366
1239, 502, 1241, 165, 998
1240, 450, 666, 73, 1165
1241, 996, 1004, 994, 1242
1242, 773, 1065, 349, 348
1243, 451, 75, 577, 686
1244, 1219, 743, 744, 884
1245, 1292, 1288, 1074, 1291
1246, 681, 243, 682, 1318
1247, 481, 1277, 413, 30
1248, 1169, 1006, 506, 507
1249, 581, 600, 597, 726
1250, 1229, 1227, 1232, 1230
1251, 467, 802, 701, 816
1252, 1169, 662, 603, 616
1253, 56, 903, 924, 904
1254, 896, 408, 281, 385
1255, 698, 1190, 240, 823
1256, 354, 1083, 780, 355
1257, 1218, 1221, 1160, 1217
1258, 958, 408, 933, 385
1259, 958, 408, 385, 29
1260, 681, 1321, 1108, 1104
1261, 1188, 1294, 1306, 718
1262, 1160, 1161, 1214, 1221
1263, 977, 985, 987, 1162
1264, 1081, 1080, 1305, 1092
1265, 992, 1003, 1236, 1005
1266, 1081, 1094, 1092, 1305
1267, 1306, 777, 1294, 1305
1268, 722, 1195, 1331, 1192
1269, 1310, 780, 1083, 1084
1270, 1277, 6, 413, 133
1271, 1342, 633, 546, 1197
1272, 872, 878, 594, 657
1273, 484, 137, 917, 136
1274, 1210, 982, 415, 1159
1275, 964, 929, 930, 965
1276, 1209, 828, 1208, 1157
1277, 69, 663, 70, 448
1278, 712, 1251, 1172, 1250
1279, 292, 413, 944, 930
1280, 948, 937, 932, 940
1281, 709, 599, 708, 282
1282, 1159, 1246, 1245, 1207
1283, 848, 1227, 879, 876
1284, 918, 390, 894, 389
1285, 848, 879, 1163, 745
1286, 1245, 416, 997, 1246
1287, 914, 896, 915, 889
1288, 464, 594, 730, 488
1289, 494, 1213, 495, 602
1290, 1226, 885, 1222, 1162
1291, 1109, 1102, 433, 1295
1292, 977, 1162, 987, 1219
1293, 592, 612, 613, 1252
1294, 925, 919, 923, 909
1295, 843, 1167, 1155, 1243
1296, 887, 384, 898, 913
1297, 889, 925, 905, 899
1298, 1218, 497, 972, 161
1299, 775, 350, 1067, 39
1300, 163, 1228, 981, 979
1301, 982, 416, 1159, 1213
1302, 181, 1043, 521, 520
1303, 1157, 828, 709, 1209
1304, 497, 606, 605, 1218
1305, 715, 1276, 1181, 1274
1306, 508, 1250, 1172, 1168
1307, 329, 750, 330, 994
1308, 619, 1277, 1182, 620
1309, 456, 672, 570, 81
1310, 1051, 1183, 1278, 523
1311, 106, 832, 105, 277
1312, 842, 751, 843, 1243
1313, 1214, 743, 323, 976
1314, 1207, 1246, 1155, 609
1315, 384, 402, 898, 913
1316, 383, 406, 403, 913
1317, 770, 429, 1072, 40
1318, 1268, 178, 1033, 1035
1319, 948, 296, 932, 297
1320, 324, 977, 976, 1219
1321, 794, 1345, 366, 44
1322, 1006, 1168, 1018, 1021
1323, 763, 752, 420, 1247
1324, 586, 1209, 473, 128
1325, 797, 684, 247, 1350
1326, 1263, 761, 760, 1029
1327, 673, 234, 235, 696
1328, 674, 673, 235, 1288
1329, 1320, 1102, 787, 360
1330, 1073, 1284, 1282, 1285
1331, 711, 1251, 873, 1249
1332, 1363, 556, 839, 810
1333, 816, 251, 701, 467
1334, 696, 773, 235, 1288
1335, 560, 445, 214, 1154
1336, 773, 674, 235, 1288
1337, 1363, 379, 810, 811
1338, 1317, 435, 1313, 436
1339, 467, 251, 117, 816
1340, 1026, 1258, 1037, 1262
1341, 942, 936, 943, 928
1342, 1216, 1156, 1158, 604
1343, 1210, 740, 414, 983
1344, 1109, 1105, 1322, 1103
1345, 812, 1153, 380, 381
1346, 357, 783, 784, 1099
1347, 963, 929, 945, 953
1348, 460, 1316, 537, 1318
1349, 796, 865, 685, 1348
1350, 135, 286, 1251, 922
1351, 135, 286, 593, 1251
1352, 1134, 1348, 1133, 796
1353, 1135, 1134, 796, 1202
1354, 1142, 1348, 1143, 1134
1355, 609, 494, 602, 1207
1356, 434, 541, 17, 198
1357, 685, 248, 796, 1202
1358, 358, 357, 784, 1099
1359, 882, 1107, 783, 782
1360, 703, 827, 127, 261
1361, 1348, 1139, 550, 1202
1362, 566, 108, 567, 840
1363, 824, 786, 785, 1319
1364, 1357, 804, 734, 868
1365, 813, 1153, 381, 1154
1366, 1208, 1157, 828, 886
1367, 1352, 1203, 1351, 1349
1368, 410, 65, 392, 52
1369, 1138, 439, 440, 1196
1370, 1117, 1331, 363, 791
1371, 328, 749, 1236, 748
1372, 1305, 1094, 1309, 1082
1373, 1318, 1106, 1316, 1095
1374, 65, 397, 52, 410
1375, 719, 1309, 1082, 1305
1376, 1003, 1238, 1005, 998
1377, 221, 1201, 25, 689
1378, 912, 49, 902, 895
1379, 1206, 1243, 740, 1207
1380, 1007, 171, 509, 172
1381, 1235, 991, 748, 747
1382, 1244, 1155, 1242, 1245
1383, 509, 1254, 172, 510
1384, 577, 1171, 686, 1266
1385, 656, 1328, 639, 1189
1386, 1275, 850, 854, 837
1387, 397, 390, 52, 410
1388, 1156, 495, 602, 604
1389, 946, 930, 965, 954
1390, 764, 39, 1055, 341
1391, 222, 1167, 690, 663
1392, 1221, 1219, 987, 1225
1393, 1320, 1101, 1109, 1102
1394, 1226, 885, 879, 1222
1395, 962, 395, 943, 399
1396, 1225, 1221, 972, 987
1397, 1236, 1235, 992, 748
1398, 2, 97, 462, 689
1399, 265, 266, 113, 829
1400, 265, 466, 112, 1363
1401, 650, 617, 1299, 659
1402, 1190, 787, 1295, 823
1403, 882, 1316, 1317, 857
1404, 1362, 830, 829, 266
1405, 780, 1084, 781, 355
1406, 1312, 779, 354, 780
1407, 288, 482, 1172, 287
1408, 1221, 984, 972, 987
1409, 837, 850, 821, 1269
1410, 292, 413, 291, 944
1411, 570, 1269, 585, 1259
1412, 1172, 1170, 712, 1250
1413, 1252, 1274, 289, 1174
1414, 410, 65, 393, 392
1415, 981, 1225, 972, 987
1416, 298, 299, 937, 949
1417, 725, 300, 597, 653
1418, 49, 56, 54, 912
1419, 1200, 1141, 1347, 1346
1420, 364, 365, 1118, 792
1421, 867, 823, 1300, 853
1422, 1170, 754, 712, 1250
1423, 300, 299, 476, 653
1424, 441, 1345, 366, 1132
1425, 963, 929, 927, 939
1426, 25, 1201, 704, 689
1427, 654, 1336, 633, 598
1428, 831, 487, 730, 729
1429, 1007, 1170, 1023, 1020
1430, 925, 900, 890, 922
1431, 1290, 1076, 1284, 1061
1432, 1068, 188, 1070, 1292
1433, 1253, 1252, 1174, 1254
1434, 1239, 329, 749, 993
1435, 600, 846, 707, 726
1436, 1070, 188, 528, 1292
1437, 1251, 642, 611, 1168
1438, 1216, 1218, 605, 1160
1439, 1239, 223, 817, 690
1440, 357, 1098, 783, 1099
1441, 1164, 450, 1166, 652
1442, 188, 529, 528, 1292
1443, 1170, 1011, 1020, 1253
1444, 136, 285, 922, 917
1445, 300, 725, 597, 726
1446, 1029, 1265, 1030, 1038
1447, 1180, 1046, 766, 1181
1448, 1276, 520, 1181, 618
1449, 1259, 1260, 1269, 585
1450, 289, 592, 1252, 916
1451, 570, 1269, 623, 585
1452, 290, 919, 413, 916
1453, 508, 1172, 1170, 612
1454, 841, 1191, 1203, 246
1455, 591, 1187, 1188, 595
1456, 922, 1251, 287, 286
1457, 350, 1066, 349, 774
1458, 461, 683, 91, 92
1459, 47, 806, 1358, 807
1460, 870, 1324, 883, 1314
1461, 423, 1258, 1037, 1026
1462, 1253, 1170, 1254, 1020
1463, 756, 1253, 334, 755
1464, 288, 1252, 877, 1170
1465, 509, 1252, 613, 612
1466, 482, 922, 135, 1251
1467, 394, 391, 920, 392
1468, 1170, 755, 877, 754
1469, 1022, 1254, 1255, 1017
1470, 759, 1262, 1263, 1027
1471, 428, 518, 1272, 179
1472, 1013, 756, 335, 757
1473, 1303, 1092, 1304, 1305
1474, 1102, 432, 433, 1295
1475, 1057, 1273, 1055, 1045
1476, 713, 1253, 755, 877
1477, 1277, 6, 481, 413
1478, 1253, 1022, 1255, 1173
1479, 1061, 527, 187, 186
1480, 527, 571, 1290, 528
1481, 237, 676, 822, 238
1482, 991, 1235, 748, 992
1483, 328, 1236, 992, 748
1484, 1177, 234, 696, 821
1485, 918, 904, 920, 924
1486, 83, 526, 1283, 675
1487, 287, 482, 1172, 1251
1488, 1253, 1170, 877, 1252
1489, 911, 926, 903, 924
1490, 621, 1299, 648, 1183
1491, 571, 655, 1185, 528
1492, 299, 130, 937, 931
1493, 236, 1285, 674, 773
1494, 299, 937, 934, 931
1495, 934, 409, 300, 931
1496, 1047, 1182, 1048, 1056
1497, 1312, 1083, 780, 354
1498, 358, 359, 1100, 785
1499, 754, 1170, 712, 877
1500, 299, 934, 300, 931
1501, 1198, 298, 1336, 1338
1502, 1093, 1312, 1083, 1310
1503, 1198, 298, 723, 1336
1504, 682, 538, 460, 90
1505, 593, 1224, 1251, 286
1506, 713, 1174, 1253, 1252
1507, 1093, 1312, 1091, 1083
1508, 1198, 298, 297, 723
1509, 887, 902, 888, 921
1510, 955, 969, 948, 939
1511, 1296, 853, 1297, 1298
1512, 960, 933, 938, 950
1513, 86, 1279, 572, 458
1514, 1010, 754, 1170, 1250
1515, 1190, 87, 679, 678
1516, 603, 1168, 1169, 507
1517, 918, 911, 904, 924
1518, 1198, 1197, 1340, 632
1519, 959, 60, 935, 938
1520, 1021, 1250, 1023, 1016
1521, 959, 951, 960, 938
1522, 863, 1328, 721, 875
1523, 462, 634, 1337, 598
1524, 1327, 43, 799, 1137
1525, 1162, 1161, 1220, 1225
1526, 911, 903, 904, 924
1527, 606, 1224, 645, 483
1528, 203, 1123, 1121, 1342
1529, 1019, 753, 1009, 1249
1530, 1337, 633, 1336, 598
1531, 792, 1197, 1339, 723
1532, 1348, 221, 580, 1201
1533, 1198, 298, 1338, 297
1534, 960, 933, 941, 938
1535, 814, 445, 45, 1204
1536, 1340, 1123, 546, 1197
1537, 560, 559, 814, 1154
1538, 441, 1343, 1341, 1345
1539, 967, 938, 927, 952
1540, 1201, 689, 462, 704
1541, 934, 958, 957, 300
1542, 808, 447, 48, 1361
1543, 937, 940, 956, 949
1544, 1224, 711, 286, 836
1545, 299, 937, 949, 934
1546, 504, 1167, 999, 1244
1547, 69, 1167, 663, 448
1548, 750, 751, 330, 1243
1549, 745, 417, 36, 978
1550, 1146, 1349, 1136, 1144
1551, 485, 599, 484, 282
1552, 1327, 799, 858, 1352
1553, 937, 940, 949, 934
1554, 289, 1274, 1276, 290
1555, 1167, 596, 1155, 1244
1556, 340, 1265, 762, 763
1557, 1290, 1076, 1070, 1288
1558, 1177, 234, 673, 696
1559, 734, 149, 568, 735
1560, 1280, 1184, 871, 1286
1561, 735, 149, 311, 734
1562, 754, 1010, 1011, 333
1563, 988, 1234, 1241, 1233
1564, 1098, 1099, 1110, 1318
1565, 648, 1277, 591, 480
1566, 960, 933, 966, 941
1567, 1114, 1325, 1323, 439
1568, 1318, 783, 1099, 784
1569, 1018, 1247, 422, 421
1570, 490, 868, 734, 568
1571, 385, 386, 407, 950
1572, 331, 753, 1009, 1019
1573, 951, 401, 405, 400
1574, 868, 735, 734, 568
1575, 1127, 1112, 1124, 1329
1576, 797, 1135, 1350, 1136
1577, 419, 988, 164, 1233
1578, 596, 474, 1, 1155
1579, 438, 1326, 1325, 1327
1580, 1337, 724, 1336, 860
1581, 1158, 484, 604, 1212
1582, 967, 938, 941, 927
1583, 917, 889, 283, 899
1584, 453, 78, 454, 670
1585, 1247, 578, 641, 1165
1586, 1240, 1002, 1005, 989
1587, 602, 1208, 609, 1207
1588, 712, 1251, 287, 1172
1589, 484, 917, 283, 1160
1590, 967, 938, 960, 941
1591, 1201, 1345, 861, 1199
1592, 753, 1009, 1249, 873
1593, 1335, 1129, 1331, 1192
1594, 1328, 1192, 1193, 1334
1595, 1218, 980, 161, 972
1596, 1038, 1268, 1040, 1035
1597, 769, 1050, 1049, 1048
1598, 577, 1268, 516, 517
1599, 980, 496, 161, 160
1600, 1267, 1035, 1038, 1025
1601, 1334, 1332, 1127, 1129
1602, 1234, 1003, 1235, 1237
1603, 1347, 549, 580, 1348
1604, 161, 497, 972, 162
1605, 1213, 416, 971, 982
1606, 43, 438, 1137, 1327
1607, 1200, 443, 442, 1344
1608, 1156, 602, 1213, 1207
1609, 1164, 226, 666, 1165
1610, 1245, 416, 415, 997
1611, 1246, 505, 168, 1244
1612, 1349, 1136, 1144, 1137
1613, 500, 501, 1233, 164
1614, 842, 828, 1155, 843
1615, 504, 999, 168, 1244
1616, 975, 984, 1214, 976
1617, 498, 981, 1225, 162
1618, 1206, 1159, 1245, 1207
1619, 607, 1230, 499, 608
1620, 1348, 96, 685, 550
1621, 1164, 1227, 692, 1165
1622, 740, 35, 414, 983
1623, 1294, 717, 1188, 1299
1624, 321, 35, 740, 983
1625, 1200, 443, 1141, 442
1626, 1260, 837, 1259, 1269
1627, 879, 1226, 745, 744
1628, 1120, 1194, 1197, 1341
1629, 995, 35, 414, 1243
1630, 1247, 1268, 1032, 1171
1631, 1215, 742, 322, 975
1632, 735, 150, 568, 107
1633, 1024, 1264, 1261, 1036
1634, 637, 93, 1203, 635
1635, 232, 233, 671, 695
1636, 519, 610, 1272, 1179
1637, 1210, 415, 973, 414
1638, 1121, 1342, 1344, 443
1639, 1197, 1120, 1128, 1121
1640, 1268, 178, 517, 1033
1641, 513, 1034, 514, 1264
1642, 1263, 761, 230, 760
1643, 1121, 1197, 1342, 1123
1644, 1029, 1265, 1038, 668
1645, 1265, 1171, 1268, 1266
1646, 442, 1194, 1120, 1343
1647, 511, 510, 173, 1255
1648, 974, 835, 983, 321
1649, 515, 1025, 668, 514
1650, 515, 177, 1267, 1025
1651, 670, 1263, 1264, 453
1652, 428, 179, 1272, 1042
1653, 1180, 1043, 1059, 1052
1654, 1011, 1253, 1012, 1020
1655, 570, 672, 1177, 1259
1656, 1279, 622, 579, 458
1657, 765, 1179, 1273, 854
1658, 1295, 434, 1301, 433
1659, 769, 768, 1183, 1048
1660, 967, 952, 927, 961
1661, 1303, 530, 1077, 1301
1662, 417, 1163, 1231, 418
1663, 1064, 1282, 1073, 1075
1664, 735, 278, 150, 107
1665, 568, 735, 107, 279
1666, 1185, 674, 1289, 1288
1667, 571, 1185, 1290, 528
1668, 1076, 1065, 1288, 1285
1669, 1287, 676, 1286, 1282
1670, 751, 750, 843, 1243
1671, 1089, 434, 433, 1301
1672, 350, 1066, 774, 1067
1673, 233, 672, 821, 234
1674, 773, 1066, 1065, 1288
1675, 735, 278, 107, 279
1676, 1283, 1287, 1069, 1282
1677, 892, 897, 919, 908
1678, 508, 1250, 1170, 1172
1679, 1183, 522, 621, 523
1680, 1273, 341, 764, 1055
1681, 1226, 325, 745, 744
1682, 1044, 1055, 1273, 1271
1683, 765, 1179, 1274, 1181
1684, 1257, 425, 1015, 511
1685, 867, 859, 1299, 717
1686, 1080, 351, 352, 777
1687, 1335, 1113, 1122, 201
1688, 1278, 622, 1184, 1281
1689, 430, 431, 1278, 1281
1690, 871, 771, 1280, 1286
1691, 1302, 776, 1298, 1297
1692, 1310, 780, 1312, 1083
1693, 651, 1189, 626, 534
1694, 1317, 42, 1107, 782
1695, 1312, 1186, 1082, 719
1696, 538, 537, 1104, 1318
1697, 1323, 1330, 1193, 1205
1698, 948, 955, 932, 296
1699, 1176, 1261, 1259, 1258
1700, 617, 643, 1296, 1299
1701, 1324, 636, 1191, 574
1702, 912, 926, 902, 921
1703, 1114, 1325, 1326, 1323
1704, 377, 1359, 807, 1358
1705, 332, 1010, 1009, 873
1706, 921, 898, 55, 913
1707, 38, 423, 758, 1037
1708, 963, 969, 939, 967
1709, 243, 699, 682, 1318
1710, 974, 835, 321, 741
1711, 773, 1066, 349, 1065
1712, 299, 654, 477, 476
1713, 1359, 1360, 1358, 561
1714, 790, 1116, 362, 1332
1715, 742, 1215, 741, 844
1716, 1353, 1146, 1350, 1140
1717, 1224, 642, 645, 593
1718, 905, 902, 921, 888
1719, 1294, 1302, 1298, 1301
1720, 856, 1313, 883, 781
1721, 851, 1249, 1248, 1223
1722, 873, 1009, 332, 753
1723, 1234, 1241, 1233, 1166
1724, 519, 179, 180, 1042
1725, 190, 1087, 532, 1304
1726, 1127, 1124, 1114, 1323
1727, 630, 1328, 1334, 1192
1728, 1181, 519, 1052, 1042
1729, 1319, 1321, 1111, 1108
1730, 431, 430, 1071, 1281
1731, 769, 1050, 1278, 429
1732, 1287, 1060, 1075, 1071
1733, 1057, 1179, 1042, 1054
1734, 1201, 584, 1199, 462
1735, 1291, 1066, 1074, 1067
1736, 550, 1130, 1139, 1348
1737, 1198, 660, 647, 1338
1738, 1199, 634, 1337, 462
1739, 1240, 70, 664, 663
1740, 1317, 435, 1097, 1107
1741, 1123, 1197, 1128, 1121
1742, 1051, 522, 183, 1053
1743, 395, 962, 66, 399
1744, 724, 269, 463, 725
1745, 1274, 714, 854, 715
1746, 797, 684, 1350, 1202
1747, 636, 1191, 635, 553
1748, 386, 407, 950, 935
1749, 1353, 1349, 1144, 1351
1750, 553, 552, 1353, 635
1751, 1313, 1317, 857, 781
1752, 1350, 94, 688, 637
1753, 1350, 551, 94, 637
1754, 1286, 1063, 1075, 1064
1755, 463, 724, 725, 653
1756, 1047, 1182, 1056, 1059
1757, 808, 1359, 1360, 807
1758, 810, 1151, 1361, 378
1759, 380, 1362, 811, 1152
1760, 39, 1271, 426, 1067
1761, 182, 1043, 1053, 521
1762, 276, 736, 832, 152
1763, 1182, 1058, 1048, 1056
1764, 1310, 1083, 1093, 1085
1765, 519, 1181, 1179, 1042
1766, 1109, 1320, 1111, 1101
1767, 1287, 1071, 1286, 1281
1768, 1304, 1092, 1303, 1077
1769, 1088, 1311, 1093, 1086
1770, 538, 89, 681, 1321
1771, 1191, 93, 1203, 246
1772, 1076, 1288, 1284, 1285
1773, 1316, 682, 683, 699
1774, 914, 905, 921, 888
1775, 1181, 1057, 1052, 1059
1776, 1181, 1180, 1059, 1052
1777, 1065, 1285, 1073, 1064
1778, 827, 127, 261, 260
1779, 153, 34, 737, 315
1780, 625, 1309, 532, 1307
1781, 254, 253, 318, 156
1782, 268, 559, 267, 814
1783, 1354, 46, 444, 371
1784, 779, 1312, 354, 1082
1785, 926, 905, 902, 921
1786, 508, 611, 1172, 612
1787, 1317, 42, 435, 1107
1788, 262, 1155, 26, 1
1789, 921, 898, 902, 55
1790, 990, 417, 1001, 1231
1791, 1190, 572, 1295, 541
1792, 408, 896, 281, 915
1793, 294, 947, 932, 930
1794, 541, 572, 459, 1190
1795, 1052, 519, 180, 1042
1796, 1316, 699, 882, 783
1797, 1174, 1252, 613, 1254
1798, 1300, 629, 1295, 572
1799, 358, 1099, 784, 1100
1800, 122, 826, 148, 469
1801, 16, 431, 184, 524
1802, 1077, 1304, 1087, 190
1803, 1277, 291, 413, 30
1804, 1297, 432, 1295, 433
1805, 486, 409, 281, 138
1806, 621, 1299, 659, 648
1807, 1297, 1296, 1301, 1295
1808, 408, 281, 385, 29
1809, 534, 1088, 1086, 1311
1810, 1099, 784, 1108, 1318
1811, 1104, 539, 1321, 1096
1812, 591, 1187, 133, 1188
1813, 824, 679, 241, 698
1814, 724, 463, 598, 653
1815, 533, 192, 1078, 191
1816, 1236, 1239, 993, 1005
1817, 1251, 642, 593, 611
1818, 1168, 611, 507, 642
1819, 784, 1099, 1108, 1100
1820, 1295, 434, 433, 1103
1821, 266, 830, 267, 114
1822, 711, 287, 1251, 286
1823, 252, 468, 319, 118
1824, 1294, 1296, 1301, 1298
1825, 556, 263, 810, 1361
1826, 1197, 860, 1341, 1337
1827, 839, 264, 810, 556
1828, 1105, 1109, 1322, 1111
1829, 1303, 1302, 1089, 1092
1830, 1066, 1291, 774, 1067
1831, 80, 79, 671, 455
1832, 1029, 1263, 1028, 760
1833, 1302, 1079, 1089, 1092
1834, 1103, 1109, 433, 1295
1835, 430, 1280, 1062, 1071
1836, 1079, 1297, 1089, 433
1837, 717, 648, 1299, 1183
1838, 1057, 1181, 1052, 1042
1839, 1190, 698, 240, 679
1840, 621, 1183, 523, 579
1841, 603, 1168, 1223, 1169
1842, 775, 1291, 696, 850
1843, 273, 141, 102, 101
1844, 1319, 1100, 1108, 1111
1845, 1337, 860, 1336, 1197
1846, 603, 1168, 642, 1223
1847, 1073, 1076, 1284, 1285
1848, 1318, 681, 1108, 1104
1849, 1079, 1302, 1089, 1297
1850, 988, 1234, 1003, 1241
1851, 101, 273, 729, 272
1852, 71, 1241, 569, 664
1853, 1078, 1087, 532, 191
1854, 926, 914, 905, 921
1855, 484, 1212, 599, 646
1856, 505, 504, 168, 1244
1857, 270, 463, 575, 98
1858, 93, 688, 1203, 246
1859, 1161, 606, 1224, 1220
1860, 1057, 1179, 1045, 1181
1861, 60, 401, 62, 959
1862, 797, 1135, 1136, 369
1863, 1273, 341, 1055, 1045
1864, 782, 882, 1317, 857
1865, 401, 951, 935, 400
1866, 28, 1360, 1361, 3
1867, 439, 1196, 1325, 1323
1868, 255, 155, 120, 254
1869, 1307, 192, 533, 534
1870, 320, 493, 739, 33
1871, 1174, 756, 1253, 1173
1872, 1126, 1197, 1198, 1339
1873, 244, 683, 699, 825
1874, 798, 369, 1136, 370
1875, 299, 130, 477, 937
1876, 1013, 756, 1012, 335
1877, 1274, 1276, 290, 715
1878, 1134, 1143, 1133, 1348
1879, 1332, 362, 789, 1115
1880, 1348, 795, 1133, 796
1881, 365, 793, 44, 1119
1882, 23, 210, 447, 1361
1883, 293, 930, 946, 954
1884, 1195, 649, 1192, 1333
1885, 882, 1107, 1316, 783
1886, 1332, 790, 789, 362
1887, 1320, 1102, 1295, 787
1888, 210, 556, 1151, 1361
1889, 56, 53, 391, 64
1890, 115, 559, 114, 267
1891, 1195, 649, 631, 1192
1892, 1134, 368, 796, 367
1893, 876, 1220, 1223, 1222
1894, 916, 592, 134, 481
1895, 1168, 508, 611, 1172
1896, 1253, 1173, 756, 1012
1897, 920, 56, 904, 391
1898, 534, 1313, 1311, 1086
1899, 390, 918, 894, 410
1900, 603, 1169, 616, 506
1901, 687, 73, 451, 74
1902, 535, 193, 437, 1086
1903, 1243, 1206, 740, 414
1904, 1092, 1303, 1302, 1305
1905, 530, 1301, 629, 541
1906, 1187, 1304, 1309, 1305
1907, 1187, 1294, 1304, 1305
1908, 773, 1066, 774, 349
1909, 589, 1195, 1338, 1333
1910, 1303, 1294, 1304, 531
1911, 1229, 978, 418, 1163
1912, 1320, 698, 679, 1319
1913, 581, 705, 464, 831
1914, 463, 269, 98, 270
1915, 269, 463, 98, 97
1916, 159, 1213, 971, 495
1917, 1027, 760, 337, 1028
1918, 1160, 1216, 1158, 604
1919, 666, 225, 818, 1166
1920, 1044, 1055, 1271, 426
1921, 100, 464, 271, 831
1922, 1180, 766, 767, 715
1923, 765, 1181, 766, 1045
1924, 709, 586, 1209, 473
1925, 915, 896, 281, 282
1926, 265, 466, 113, 112
1927, 520, 1180, 521, 619
1928, 463, 269, 270, 725
1929, 1171, 1247, 641, 1165
1930, 735, 149, 568, 150
1931, 1047, 1180, 767, 1182
1932, 132, 133, 479, 1187
1933, 775, 1291, 774, 696
1934, 288, 1170, 877, 712
1935, 409, 915, 281, 138
1936, 1322, 1319, 1111, 1320
1937, 413, 916, 481, 290
1938, 787, 1102, 1295, 432
1939, 1165, 866, 692, 819
1940, 819, 687, 692, 1165
1941, 686, 1165, 687, 819
1942, 1167, 596, 1, 1155
1943, 1338, 131, 589, 1333
1944, 866, 578, 1165, 1227
1945, 20, 203, 1342, 547
1946, 1173, 1255, 1257, 1015
1947, 1259, 615, 1176, 1260
1948, 376, 47, 806, 1358
1949, 156, 253, 119, 254
1950, 1246, 505, 11, 168
1951, 1238, 70, 503, 569
1952, 775, 1067, 350, 774
1953, 1021, 1019, 1009, 1249
1954, 1252, 638, 592, 1274
1955, 1267, 1265, 1038, 1268
1956, 1260, 615, 585, 1259
1957, 1029, 1263, 1041, 1028
1958, 1302, 776, 777, 1298
1959, 1264, 1036, 1039, 1262
1960, 1262, 1036, 1026, 1258
1961, 1176, 1261, 615, 1259
1962, 969, 941, 968, 940
1963, 413, 134, 481, 916
1964, 647, 649, 631, 1195
1965, 1279, 852, 1278, 1184
1966, 427, 1271, 1270, 1067
1967, 1184, 1287, 1286, 1281
1968, 1054, 428, 1272, 1042
1969, 1353, 208, 552, 553
1970, 621, 522, 1183, 620
1971, 1185, 674, 82, 1289
1972, 799, 370, 1352, 1137
1973, 1270, 1074, 1292, 1068
1974, 1340, 545, 546, 202
1975, 1219, 324, 744, 743
1976, 438, 1326, 43, 1125
1977, 1289, 1282, 1284, 1285
1978, 633, 1342, 634, 1337
1979, 1116, 1332, 1115, 362
1980, 813, 559, 814, 267
1981, 773, 1065, 1285, 1288
1982, 468, 739, 816, 320
1983, 1177, 673, 1185, 696
1984, 696, 850, 1291, 1177
1985, 1177, 234, 672, 673
1986, 518, 529, 1293, 623
1987, 630, 1192, 631, 649
1988, 648, 621, 1183, 620
1989, 769, 1299, 1278, 1183
1990, 290, 1274, 714, 289
1991, 289, 1276, 481, 290
1992, 916, 289, 481, 290
1993, 1268, 178, 516, 517
1994, 364, 1118, 1339, 792
1995, 1354, 801, 250, 701
1996, 563, 1356, 564, 217
1997, 104, 706, 601, 465
1998, 757, 1173, 756, 880
1999, 534, 193, 535, 1086
2000, 1348, 96, 580, 221
2001, 416, 494, 1159, 1213
2002, 926, 903, 895, 910
2003, 474, 1209, 586, 128
2004, 782, 783, 356, 1107
2005, 1218, 496, 605, 497
2006, 588, 472, 473, 708
2007, 1353, 208, 1138, 1140
2008, 75, 1266, 686, 667
2009, 574, 93, 635, 1191
2010, 996, 1206, 414, 415
2011, 1177, 1291, 696, 1185
2012, 1213, 1210, 1159, 982
2013, 1265, 761, 762, 693
2014, 1035, 516, 1267, 1268
2015, 787, 1102, 432, 41
2016, 1221, 1218, 972, 1217
2017, 991, 992, 748, 327
2018, 984, 1221, 972, 1217
2019, 136, 285, 483, 922
2020, 1328, 1308, 1333, 639
2021, 361, 1330, 789, 1115
2022, 1114, 1325, 438, 1326
2023, 880, 1256, 847, 757
2024, 1115, 1332, 1193, 789
2025, 1183, 522, 1182, 620
2026, 288, 482, 1252, 1172
2027, 592, 482, 612, 1252
2028, 606, 1220, 1225, 498
2029, 331, 1019, 37, 752
2030, 1161, 1162, 1219, 1225
2031, 1302, 1303, 1089, 1301
2032, 1226, 977, 985, 978
2033, 1229, 419, 1230, 1232
2034, 652, 1241, 449, 1166
2035, 309, 122, 256, 826
2036, 819, 866, 1171, 1165
2037, 896, 914, 385, 888
2038, 1224, 1161, 1220, 836
2039, 270, 725, 705, 575
2040, 925, 914, 915, 889
2041, 991, 1235, 1237, 747
2042, 1233, 1227, 1230, 1232
2043, 331, 753, 1019, 752
2044, 754, 1010, 1170, 1011
2045, 691, 225, 1166, 818
2046, 596, 505, 609, 1244
2047, 596, 1244, 609, 1155
2048, 1273, 341, 765, 764
2049, 1177, 1293, 1269, 1270
2050, 1246, 505, 1244, 609
2051, 876, 1220, 885, 836
2052, 1179, 1044, 1178, 1054
2053, 1177, 850, 1271, 1269
2054, 1274, 610, 1179, 1275
2055, 28, 808, 809, 1361
2056, 1246, 1244, 1155, 609
2057, 1248, 421, 1247, 1018
2058, 122, 309, 257, 147
2059, 1024, 1039, 1034, 1264
2060, 617, 1303, 1294, 1301
2061, 406, 386, 407, 888
2062, 406, 951, 400, 935
2063, 1227, 879, 876, 1222
2064, 1167, 1155, 1, 26
2065, 1234, 1232, 1231, 1164
2066, 402, 898, 913, 55
2067, 1232, 990, 1234, 1231
2068, 1233, 1227, 608, 1230
2069, 419, 1233, 1230, 1232
2070, 1208, 842, 886, 828
2071, 324, 977, 744, 325
2072, 995, 1243, 414, 996
2073, 500, 1233, 608, 1230
2074, 1233, 1227, 1164, 608
2075, 1233, 419, 1000, 1232
2076, 1167, 1240, 663, 448
2077, 911, 918, 904, 894
2078, 1234, 1232, 1233, 1000
2079, 986, 1217, 984, 980
2080, 596, 1167, 69, 448
2081, 497, 606, 1225, 498
2082, 163, 1228, 498, 981
2083, 889, 896, 915, 282
2084, 842, 886, 740, 1207
2085, 1236, 992, 1005, 993
2086, 72, 665, 666, 1166
2087, 1236, 328, 992, 993
2088, 342, 765, 766, 1045
2089, 1245, 416, 1159, 415
2090, 743, 1219, 976, 1214
2091, 236, 772, 1282, 1285
2092, 1289, 83, 571, 527
2093, 996, 995, 1243, 994
2094, 1360, 1359, 1358, 807
2095, 717, 1182, 1183, 768
2096, 1167, 750, 994, 1243
2097, 570, 1269, 1177, 623
2098, 674, 1285, 1288, 773
2099, 1065, 1285, 1064, 348
2100, 996, 1243, 1206, 1245
2101, 1206, 1159, 415, 1245
2102, 1296, 1297, 1301, 1298
2103, 1191, 1196, 1205, 1325
2104, 1353, 1138, 1144, 1140
2105, 969, 940, 968, 948
2106, 841, 1191, 858, 1352
2107, 1145, 1142, 1348, 1143
2108, 684, 1202, 248, 685
2109, 1167, 504, 596, 1244
2110, 1201, 221, 2, 689
2111, 1199, 1346, 1347, 1201
2112, 843, 842, 1243, 1155
2113, 1227, 1165, 1164, 608
2114, 1210, 1206, 740, 1207
2115, 715, 716, 767, 1180
2116, 471, 702, 472, 864
2117, 163, 12, 499, 1230
2118, 1235, 691, 1166, 818
2119, 1351, 1138, 1144, 1353
2120, 1004, 1167, 994, 1242
2121, 1349, 1351, 1352, 1137
2122, 1046, 1180, 766, 767
2123, 1208, 1209, 1155, 828
2124, 711, 753, 1249, 873
2125, 858, 1324, 1205, 1191
2126, 788, 1327, 799, 858
2127, 753, 752, 851, 1249
