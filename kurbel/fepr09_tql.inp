3060, 959.12821, 30, 67.101325
3061, 974.49332, 30, 49.49479
3062, 984.99372, 30, 27.976284
3063, 989.45168, 30, 4.1649031
3064, 987.62483, 30, -18.041034
3065, 980.88416, 30, -37.897694
3066, 968.70807, 30, -57.034265
3067, 816.1531, 30, 30.744978
3068, 828.18467, 30, 52.984812
3069, 952.27637, 30, -72.358928
3070, 933.83178, 30, -82.568312
3071, 913.54112, 30, -88.217274
3072, 890.72133, 30, -88.778438
3073, 866.93773, 30, -82.887052
3074, 846.82631, 30, -71.67039
3075, 830.13809, 30, -55.530554
3076, 818.1718, 30, -35.618555
3077, 812.04181, 30, -15.508937
3078, 810.90533, 30, 6.8766395
3079, -8.8861246, 10.649999, -199.81672
3080, 0.49066789, 10.649999, -198.7522
3081, 9.0117278, 8.0241047, -199.87721
3082, 17.615829, 8.0241047, -204.02073
3083, 6.1964582, 18.674104, -198.7522
3084, 24.154935, 7.5954931, -211.37946
3085, 28.134554, 7.5954931, -219.82694
3086, 21.891699, 15.619598, -208.54147
3087, 29.959169, 7.5139617, -227.82111
3088, 27.96244, 7.5139617, -236.92714
3089, 29.427245, 15.109455, -225.49059
3090, -29.92985, 9.0343648, -228.30735
3091, -27.895416, 9.0343648, -218.77921
3092, 24.226604, 7.2897345, -244.53067
3093, 17.557592, 7.2897345, -252.00731
3094, 26.242151, 14.803696, -242.00326
3095, 8.8830799, 7.3785779, -256.18475
3096, -0.017066045, 7.3785779, -257.2478
3097, 13.032575, 14.668312, -254.18645
3098, -8.6470533, 8.3965647, -256.29841
3099, -17.426995, 8.3965647, -252.07021
3100, -5.5693504, 15.775143, -257.2478
3101, -23.869664, 9.2567125, -244.97825
3102, -28.043004, 9.2567125, -236.57416
3103, -29.35813, 18.291077, -230.81222
3104, -21.439938, 17.653277, -248.02502
3105, -29.156089, 49.624977, -224.30258
3106, -28.692251, 49.624977, -233.72962
3107, -24.917371, 48.944373, -243.66448
3108, -18.915768, 48.944373, -251.19022
3109, -27.304941, 38.569351, -239.80783
3110, -10.645701, 51.881274, -255.33591
3111, -1.2882388, 51.881274, -257.2478
3112, -13.380153, 40.825647, -254.01907
3113, 7.5884695, 52.185405, -256.8082
3114, 15.900837, 52.185405, -252.80517
3115, 4.8708162, 44.066679, -257.2478
3116, -7.2479089, 49.93515, -199.0278
3117, -15.991131, 49.93515, -203.23832
3118, 22.973428, 52.436546, -246.10209
3119, 27.858864, 52.436546, -237.38093
3120, 21.319496, 44.621951, -248.17605
3121, 29.69534, 52.640482, -229.3348
3122, 28.236284, 52.640482, -220.27265
3123, 29.233141, 45.077029, -231.35983
3124, 25.203906, 52.833629, -212.69483
3125, 19.274361, 52.833629, -205.25944
3126, 26.996872, 45.474111, -214.94313
3127, 10.774547, 51.837331, -200.72614
3128, 1.6305296, 51.837331, -198.7522
3129, -5.1646776, 41.77248, -198.7522
3130, 14.180851, 44.670959, -202.36653
3131, -23.580215, 9.1928761, -210.65879
3132, -17.595333, 9.1928761, -204.01086
3133, -21.671781, 53.141512, -208.2657
3134, -27.127381, 53.141512, -215.41423
3135, -25.767277, 18.227241, -213.40127
3136, -12.477847, 19.842875, -201.54641
3137, -19.9799, 43.076662, -206.14416
3138, -28.163222, 42.76649, -219.95254
3139, -28.494531, 28.88169, -234.59589
3140, -24.210893, 28.201086, -244.55037
3141, -29.576703, 28.659342, -226.14542
3142, 20.204892, 23.382236, -206.42629
3143, 26.790195, 22.953625, -214.68396
3144, 28.752368, 22.692426, -222.53376
3145, 29.34937, 22.610895, -230.8506
3146, -17.974283, 27.340938, -251.80665
3147, 15.625084, 22.03359, -252.93796
3148, 6.3336866, 22.122434, -257.2478
3149, -2.0589167, 21.924276, -257.2478
3150, -10.688904, 22.942263, -255.31511
3151, 28.017675, 30.455065, -219.31486
3152, -28.487892, 35.753717, -221.37502
3153, -27.60578, 25.163105, -217.51023
3154, -22.679467, 25.321616, -209.52929
3155, -14.46385, 33.490072, -253.49718
3156, -5.5921812, 36.426972, -257.2478
3157, 2.8004221, 36.625129, -257.2478
3158, 11.67713, 36.929261, -254.8392
3159, 1.6123244, 29.289554, -257.2478
3160, 28.742432, 37.533479, -233.50977
3161, 29.35746, 37.737415, -225.18485
3162, 27.557352, 37.998614, -217.29805
3163, 23.092474, 38.19176, -210.04719
3164, 18.081312, 38.56353, -204.2449
3165, 8.793234, 37.567231, -199.77199
3166, 19.991134, 31.088033, -206.15824
3167, -17.135229, 29.128026, -203.78929
3168, -7.8010873, 30.585149, -199.29419
3169, -19.881882, 36.06389, -206.02125
3170, -24.933224, 39.270253, -212.3554
3171, 5.3912811, 26.3799, -198.7522
3172, 13.912341, 23.754006, -202.23722
3173, 27.357547, 22.436836, -239.57735
3174, 22.345432, 22.212609, -246.88957
3175, 19.525523, 37.10828, -250.42561
3176, 26.163077, 37.359421, -242.10242
3177, 27.978945, 30.019808, -236.85482
3178, 1.0773512, 32.48733, -198.7522
3179, 17.702968, 29.666731, -251.9373
3180, -178.36357, 10.150062, -137.28769
3181, -169.21524, 10.150062, -132.81065
3182, -158.62062, 10.503563, -131.73743
3183, -148.5089, 10.503563, -134.32645
3184, -164.83887, 20.653625, -131.9401
3185, -139.23363, 10.479532, -141.16469
3186, -133.44199, 10.479532, -150.05153
3187, -143.54406, 20.983095, -137.64381
3188, -131.32536, 10.210557, -160.69217
3189, -133.18578, 10.210557, -171.10104
3190, -132.05916, 20.690088, -157.00324
3191, -139.36061, 8.9940907, -181.46595
3192, -147.90433, 8.9940907, -187.71027
3193, -137.71402, 19.204647, -179.00162
3194, -156.93207, 8.9940907, -190.36732
3195, -163.02555, 18.503641, -190.86122
3196, -171.09231, 9.5095505, -189.25665
3197, -180.06538, 9.5095505, -184.01583
3198, -183.65389, 19.078619, -180.60706
3199, -187.11699, 9.5690683, -175.42418
3200, -190.36991, 9.5690683, -165.49554
3201, -191.16409, 19.298181, -160.93771
3202, -189.86713, 9.7291129, -154.41742
3203, -176.76576, 49.875671, -136.22009
3204, -184.40485, 49.875671, -142.95742
3205, -189.47573, 49.521316, -152.4497
3206, -190.91123, 49.521316, -162.77409
3207, -186.93114, 39.396988, -146.73828
3208, -188.46257, 49.401811, -173.41038
3209, -182.20618, 49.401811, -182.58539
3210, -189.8233, 38.923127, -168.24352
3211, -173.29946, 49.175359, -188.53669
3212, -162.53142, 49.175359, -190.9595
3213, -177.19811, 38.57717, -185.93168
3214, -151.13012, 49.542988, -189.21325
3215, -142.03895, 49.542988, -183.79114
3216, -155.46059, 38.718348, -190.07463
3217, -135.55685, 50.395143, -175.77314
3218, -132.07211, 50.395143, -165.50245
3219, -136.78952, 39.938132, -177.61799
3220, -132.63986, 51.490589, -154.08398
3221, -137.37392, 51.490589, -143.94799
3222, -132.3982, 41.885733, -155.29881
3223, -144.22996, 51.490589, -137.18551
3224, -148.70392, 41.762272, -134.19614
3225, -156.49025, 50.271683, -132.1612
3226, -185.88385, 9.7291129, -145.17089
3227, -166.55293, 50.271683, -132.28107
3228, -183.80249, 19.879175, -142.05593
3229, -145.28663, 31.994152, -136.47948
3230, -136.58041, 31.970121, -145.13557
3231, -132.2463, 30.874675, -156.06246
3232, -132.53988, 30.6057, -167.85401
3233, -136.6019, 29.753545, -177.33719
3234, -145.91803, 28.537079, -186.38307
3235, -156.32883, 28.16945, -190.24733
3236, -170.30414, 28.68491, -189.41342
3237, -179.7304, 28.911362, -184.23966
3238, -186.87472, 28.970879, -175.78676
3239, -190.3961, 29.090385, -165.36386
3240, -189.83878, 29.250429, -154.27488
3241, -171.86229, 40.147355, -133.3372
3242, -185.24605, 29.604784, -144.21636
3243, -156.743, 30.775246, -132.11092
3244, -167.68915, 30.421745, -132.50708
3245, -177.56218, 30.025734, -136.75223
3246, -230.5857, 8.3122356, 29.409831
3247, -221.63068, 8.3122356, 28.546245
3248, -213.52142, 7.4956039, 25.863095
3249, -206.11463, 7.4956039, 19.956356
3250, -216.25658, 15.80784, 27.319641
3251, -201.2833, 7.2096626, 11.931493
3252, -198.7522, 7.2096626, 2.8202194
3253, -202.86172, 14.705266, 15.209125
3254, -198.7522, 8.0948287, -5.8869836
3255, -202.63105, 8.0948287, -14.730139
3256, -198.7522, 15.304491, -2.552865
3257, -257.2478, 7.2482129, 5.4516731
3258, -253.50205, 7.2482129, 14.453746
3259, -207.82368, 9.7680279, -21.319281
3260, -214.98802, 9.7680279, -27.030102
3261, -204.5133, 17.862857, -18.638647
3262, -224.86753, 10.00303, -29.285035
3263, -234.44933, 10.00303, -28.527984
3264, -220.26652, 19.771058, -28.234884
3265, -243.66318, 10.288229, -24.918402
3266, -251.50538, 10.288229, -18.59987
3267, -240.79039, 20.291259, -27.080678
3268, -255.04637, 6.596821, -11.246931
3269, -257.2478, 6.596821, -2.712212
3270, -257.2478, 13.845034, 2.4479186
3271, -253.77259, 16.88505, -13.891966
3272, -255.67634, 52.117971, 9.9387958
3273, -257.2478, 52.117971, 0.46189817
3274, -256.25149, 50.856339, -8.7444833
3275, -252.23091, 50.856339, -17.093301
3276, -257.2478, 42.97431, -4.1278873
3277, -245.10344, 50.142374, -23.769835
3278, -236.56084, 50.142374, -28.046044
3279, -248.59712, 40.998713, -20.983702
3280, -227.39956, 49.79238, -29.862954
3281, -217.81335, 49.79238, -27.674964
3282, -231.10441, 39.934754, -29.291438
3283, -228.02609, 54.235947, 29.994046
3284, -237.06024, 54.235947, 27.93206
3285, -208.87806, 48.829341, -22.16012
3286, -202.98024, 48.829341, -15.455225
3287, -212.10829, 38.621721, -24.736156
3288, -199.20466, 51.926934, -7.6151609
3289, -198.7522, 51.926934, 2.0796271
3290, -199.98935, 40.756275, -9.2445969
3291, -200.50318, 52.504534, 10.311565
3292, -205.02119, 52.504534, 19.084362
3293, -199.41399, 44.431468, 8.0498484
3294, -212.43777, 52.656594, 24.998913
3295, -220.94637, 52.656594, 28.390055
3296, -226.05462, 46.892541, 29.55598
3297, -209.55778, 45.161128, 22.702183
3298, -247.9142, 8.332644, 21.528314
3299, -240.53553, 8.332644, 27.138849
3300, -244.27709, 52.715204, 24.428828
3301, -251.48841, 52.715204, 18.635114
3302, -251.23772, 15.580857, 18.877886
3303, -235.63639, 16.64488, 28.257045
3304, -241.41861, 46.951151, 26.708396
3305, -253.3847, 44.833175, 14.697423
3306, -257.2478, 35.938399, 1.6000176
3307, -256.58213, 34.676767, -8.0579101
3308, -235.72796, 30.145404, -28.236144
3309, -226.13563, 29.79541, -29.57447
3310, -244.80127, 30.430603, -24.010802
3311, -216.25612, 29.560408, -27.319537
3312, -204.42442, 22.296436, 18.454089
3313, -200.11111, 22.010495, 9.4974378
3314, -198.7522, 21.308629, 1.9546695
3315, -198.99007, 22.193795, -7.1695783
3316, -198.7522, 28.899798, 6.012635
3317, -254.41011, 24.108657, -12.568139
3318, -257.2478, 20.417249, -4.0017134
3319, -254.08328, 22.362757, 13.246803
3320, -248.85783, 23.447188, 20.775795
3321, -252.21112, 31.144568, -17.13439
3322, -200.39256, 32.928307, -10.081875
3323, -198.7522, 36.0259, -1.2135444
3324, -198.7522, 36.727766, 6.3292239
3325, -202.54968, 37.305367, 14.561162
3326, -207.73381, 37.82024, 21.247612
3327, -215.74354, 37.972299, 27.202543
3328, -206.0766, 30.116538, 19.926022
3329, -239.73828, 24.675473, 27.320816
3330, -228.9903, 24.655064, 29.773971
3331, -233.45889, 40.578776, 28.754044
3332, -241.67504, 39.058032, 26.503897
3333, -218.79461, 23.627941, 27.89893
3334, -210.99708, 22.811309, 23.84999
3335, -226.44855, 38.999423, 29.645891
3336, -222.30801, 31.658534, 28.700842
3337, -243.75499, 31.457373, 24.845189
3338, -250.43991, 37.829748, 19.514119
3339, -255.24476, 37.232515, 10.834983
3340, -256.9923, 28.934972, 7.2061721
3341, -257.2478, 21.068641, 4.5711731
3342, -202.36244, 26.92417, -14.172365
3343, -207.43333, 28.597369, -21.007986
3344, -178.29578, 10.147181, 185.19824
3345, -169.09197, 10.147181, 189.65454
3346, -158.50136, 10.498104, 190.67947
3347, -148.37359, 10.498104, 188.02382
3348, -164.70194, 20.645285, 190.52776
3349, -139.12596, 10.449765, 181.11477
3350, -133.39723, 10.449765, 172.16405
3351, -143.42975, 20.947869, 184.72045
3352, -131.27522, 10.259845, 161.49641
3353, -133.25068, 10.259845, 151.01328
3354, -132.02415, 20.70961, 165.26137
3355, -138.86104, 9.9093623, 141.72233
3356, -147.4059, 9.9093623, 135.06344
3357, -137.2763, 20.169208, 144.09408
3358, -157.1919, 9.8169579, 132.02163
3359, -168.11376, 9.8169579, 132.59155
3360, -155.53925, 19.72632, 132.35037
3361, -177.99675, 8.6845344, 137.04259
3362, -185.76024, 8.6845344, 144.9859
3363, -177.36719, 18.501492, 136.62194
3364, -189.74881, 8.6845344, 153.82256
3365, -190.90502, 18.536095, 159.63529
3366, -189.90862, 9.851561, 167.8146
3367, -176.50338, 49.709328, 186.39589
3368, -184.27085, 49.709328, 179.68372
3369, -189.54921, 49.636292, 169.62146
3370, -190.78929, 49.636292, 159.05345
3371, -186.87837, 39.34562, 175.78131
3372, -187.64856, 49.412398, 147.81197
3373, -181.41576, 49.412398, 139.32708
3374, -189.58942, 39.048689, 153.02125
3375, -172.77219, 49.799537, 133.5517
3376, -162.28609, 49.799537, 131.43231
3377, -175.70956, 39.211935, 135.51436
3378, -151.7346, 50.047062, 133.10719
3379, -142.61319, 50.047062, 138.26579
3380, -154.757, 39.846599, 132.50598
3381, -135.89605, 50.47801, 146.15979
3382, -132.10781, 50.47801, 156.75867
3383, -136.89269, 40.525072, 144.6682
3384, -132.59524, 51.57172, 168.13233
3385, -137.2707, 51.57172, 178.33813
3386, -132.37878, 42.04973, 167.04414
3387, -144.12135, 51.57172, 185.18256
3388, -148.54933, 41.822597, 188.14125
3389, -156.33134, 50.250877, 190.24783
3390, -185.84512, 9.851561, 177.32767
3391, -166.43443, 50.250877, 190.18315
3392, -183.72907, 19.998742, 180.49455
3393, -145.17214, 32.069823, 185.88468
3394, -136.48607, 32.021485, 177.16384
3395, -132.22364, 30.927776, 166.26425
3396, -132.56844, 30.737856, 154.44298
3397, -136.73416, 30.306907, 144.90546
3398, -145.05136, 29.956424, 136.63667
3399, -154.48743, 29.708899, 132.5596
3400, -166.05339, 29.616495, 132.1817
3401, -175.67452, 29.229355, 135.49095
3402, -184.83087, 28.096932, 143.59502
3403, -189.76377, 28.320826, 153.8978
3404, -189.88907, 29.487853, 167.91291
3405, -171.44355, 39.960205, 189.18678
3406, -185.02889, 29.560889, 178.54923
3407, -156.56773, 30.748981, 190.29485
3408, -167.51882, 30.398058, 189.96745
3409, -177.23201, 29.856509, 185.90904
3410, -8.7641036, 7.8555536, 256.24204
3411, 0.76637212, 7.8555536, 257.2478
3412, 9.8673454, 7.5936729, 255.71075
3413, 18.561456, 7.5936729, 251.52388
3414, 6.4043843, 15.449226, 257.2478
3415, 24.572405, 7.6845627, 244.09705
3416, 28.203012, 7.6845627, 235.87312
3417, 22.250708, 15.278236, 247.00835
3418, 29.872935, 7.2671175, 227.44329
3419, 27.681107, 7.2671175, 217.84026
3420, 29.572318, 14.95168, 229.8738
3421, -29.892895, 9.3151381, 227.53074
3422, -27.879418, 9.3151381, 237.29088
3423, 22.772819, 7.3069613, 209.64635
3424, 16.138006, 7.3069613, 203.30905
3425, 24.872851, 14.574079, 212.2797
3426, 8.5691166, 7.2724633, 199.66406
3427, -0.78106501, 7.2724633, 198.7522
3428, 10.914958, 14.579425, 200.79376
3429, -9.422075, 7.787584, 200.07482
3430, -17.929542, 7.787584, 204.17181
3431, -6.0671148, 15.060047, 198.7522
3432, -23.894169, 9.0450936, 211.05247
3433, -27.940053, 9.0450936, 218.97478
3434, -29.324306, 18.360232, 225.03959
3435, -29.499739, 49.394548, 230.19179
3436, -28.328842, 49.394548, 220.67818
3437, -24.66012, 48.75123, 212.01294
3438, -18.739191, 48.75123, 204.58836
3439, -27.167299, 38.145778, 215.58912
3440, -9.8717757, 51.944757, 200.29139
3441, -0.89128546, 51.944757, 198.7522
3442, -13.541477, 40.695987, 202.05862
3443, 7.7356153, 52.464907, 199.26266
3444, 16.429726, 52.464907, 203.44953
3445, 5.2479026, 44.409664, 198.7522
3446, -6.1818081, 53.690912, 257.2478
3447, -14.782594, 53.690912, 253.34369
3448, 23.09988, 52.553627, 210.05647
3449, 27.651909, 52.553627, 217.71234
3450, 21.123921, 45.018533, 207.57871
3451, 29.581559, 52.602352, 226.16669
3452, 28.202354, 52.602352, 235.87601
3453, 29.07417, 45.155979, 223.94367
3454, 24.814528, 52.668739, 243.79344
3455, 18.915116, 52.668739, 251.19103
3456, 26.94013, 45.271092, 241.12803
3457, 10.525663, 52.889263, 255.39372
3458, 1.4845324, 52.889263, 257.2478
3459, -3.6794225, 46.580175, 257.2478
3460, 13.905493, 45.558003, 253.76608
3461, -23.647733, 8.5390733, 245.25655
3462, -17.410236, 8.5390733, 252.07828
3463, -21.217571, 49.845215, 248.30386
3464, -27.136528, 49.845215, 240.5457
3465, -25.794407, 17.854211, 242.56471
3466, -12.702102, 16.394627, 254.3456
3467, -18.772177, 43.536127, 251.37027
3468, -28.128046, 39.239763, 236.20157
3469, -27.226088, 29.160353, 240.15331
3470, -29.792862, 28.709686, 228.90753
3471, -21.998424, 28.384288, 247.3247
3472, -28.233783, 28.439641, 220.2617
3473, 20.404493, 22.778147, 249.32342
3474, 26.77776, 22.869037, 241.33163
3475, 28.997148, 22.856711, 232.39378
3476, 28.991511, 22.439265, 223.58152
3477, -17.687337, 35.963129, 251.94483
3478, -14.909387, 24.656988, 253.28262
3479, 13.82221, 22.143613, 202.19382
3480, 5.867234, 22.109115, 198.7522
3481, -2.3170026, 21.455973, 198.7522
3482, -10.958013, 21.971093, 200.81449
3483, -14.83532, 32.93474, 202.68171
3484, -5.2934492, 36.128266, 198.7522
3485, 2.8907873, 36.781409, 198.7522
3486, 11.517688, 37.301559, 201.08402
3487, 22.819211, 37.853213, 246.29548
3488, 16.38667, 38.204679, 252.5712
3489, 19.001876, 30.720414, 251.08224
3490, -5.6529495, 23.973468, 257.2478
3491, -9.7349036, 39.808826, 255.77453
3492, 3.7837851, 23.391494, 257.2478
3493, 12.884758, 23.129613, 254.25764
3494, 27.034211, 22.440951, 215.00603
3495, 20.739205, 22.480795, 207.09629
3496, 18.969131, 37.63874, 204.8767
3497, 17.331759, 30.010485, 203.88393
3498, 0.62646814, 29.020161, 198.7522
3499, -112.02078, 235.52767, 48.730156
3500, -89.684964, 232.4715, 79.234052
3501, -98.442369, 271.46951, 71.044569
3502, 27.668731, 35.517224, 196.29213
3503, 28.338883, 24.734672, 198.21171
3504, 20.777344, 35.180043, 191.33648
3505, 33.064268, 29.90423, 184.64365
3506, 21.447496, 24.397491, 193.25606
3507, -270.42737, 42.857775, -23.922928
3508, -284.69955, 45.698994, -30.537117
3509, -270.98868, 42.857775, -39.188326
3510, -282.82668, 28.556769, -31.580222
3511, -285.26085, 45.698994, -45.802515
3512, -260.68473, 13.89049, 44.97772
3513, -280.98843, 13.89049, 48.632911
3514, -255.45998, 13.89049, 62.541475
3515, 1269.2536, 45.083077, -35.930356
3516, -267.10548, 23.135252, -1.1095976
3517, -262.90115, 26.678203, -13.422246
3518, -267.10548, 15.911645, -3.232852
3519, -272.75884, 22.172598, -12.653384
3520, -262.90115, 19.454596, -15.5455
3521, -41.927276, 96.558825, 112.01653
3522, -33.998631, 77.184732, 116.12394
3523, -21.036202, 94.02726, 120.58821
3524, -265.87626, 6.596821, -7.3810677
3525, -254.38037, 33.000149, -26.090021
3526, -256.25324, 50.142374, -25.046916
3527, -256.81454, 50.142374, -40.312314
3528, 107.4729, 211.63946, 55.200381
3529, 117.25436, 227.38587, 20.454278
3530, 117.14481, 188.88309, 32.108131
3531, 12.938344, 43.81729, 139.39409
3532, 14.170061, 26.054916, 144.84833
3533, 2.9015945, 34.825812, 147.26873
3534, 20.063481, 42.237625, 153.33242
3535, 8.7950147, 51.008522, 155.75282
3536, 10.026731, 33.246147, 161.20706
3537, -261.29783, 33.714114, -19.150151
3538, -263.1707, 50.856339, -18.107046
3539, -141.99208, 44.480576, 235.79236
3540, -160.05592, 44.480576, 231.51724
3541, -148.34182, 29.013056, 227.02043
3542, -124.72928, 44.532479, 213.69631
3543, -142.79312, 44.532479, 209.42119
3544, -288.44444, 39.314824, 0.31868227
3545, -287.56066, 9.3148238, -12.294615
3546, -287.03101, 25.013818, -19.267573
3547, 1067.2357, 30.271817, 8.1484158
3548, 1070.0759, 29.14036, 26.901055
3549, 1070.0198, 44.882206, 26.765807
3550, -131.44719, 21.930081, 136.92965
3551, -119.51836, 12.020718, 128.24619
3552, -120.23777, 27.218073, 121.48545
3553, -134.18267, 9.9093623, 127.24487
3554, -134.90208, 25.106717, 120.48413
3555, -122.97325, 15.197355, 111.80067
3556, -0.43261513, 32.050715, -155.10975
3557, 16.66618, 27.358042, -165.75835
3558, 9.4199405, 36.852564, -167.2543
3559, -4.9536879, 25.502713, -167.1494
3560, -12.199927, 34.997235, -168.64535
3561, 4.8988677, 30.304561, -179.29395
3562, -263.64635, 42.629699, -8.315746
3563, -270.90302, 34.631135, -14.131628
3564, -272.77589, 51.77336, -13.088523
3565, -188.76939, 8.6845344, 134.358
3566, 1035.5249, 16.154972, -7.8883749
3567, 1034.1399, 46.154972, -0.79088013
3568, 1050.0257, 31.037178, 5.4959584
3569, 1022.7667, 30, 6.6405576
3570, 1038.6524, 14.882206, 12.927396
3571, 1037.2674, 44.882206, 20.024891
3572, 1063.8405, 30, 118.84203
3573, 1075.8329, 30, 82.251156
3574, 1103.071, 30, 118.02884
3575, 74.728873, 45.516866, 189.93692
3576, 56.887771, 43.153633, 176.22827
3577, 59.933944, 44.035295, 193.582
3578, 75.585807, 28.670499, 183.06394
3579, 78.63198, 29.552161, 200.41767
3580, 60.790878, 27.188928, 186.70902
3581, -153.53611, 31.991635, 1.5402534
3582, -168.67689, 46.319236, 5.7914526
3583, -170.59538, 34.810152, 4.67736
3584, -162.67661, 45.6724, -10.920305
3585, -164.5951, 34.163317, -12.034397
3586, -179.73589, 48.490917, -7.7831981
3587, -67.117708, 16.221116, 181.83146
3588, -54.467854, 31.191035, 178.45078
3589, -79.359502, 31.048434, 183.17178
3590, -65.368585, 14.969919, 162.49429
3591, -90.260232, 14.827318, 167.21529
3592, -77.610379, 29.797237, 163.83461
3593, 1046.2557, 30, -97.00006
3594, 1064.2792, 30, -129.12786
3595, 1070.8873, 30, -78.071896
3596, 312.86907, 30, -16.849694
3597, 280.74927, 30, 31.691456
3598, 346.47873, 30, 17.14306
3599, 1066.9744, 44.882206, 10.133915
3600, 1053.9024, 44.882206, 26.630795
3601, 1063.8468, 46.154972, -10.681856
3602, 1050.7748, 46.154972, 5.8150236
3603, -166.75772, 25.024042, 118.6409
3604, -178.65897, 15.207084, 113.86807
3605, -174.72045, 34.619482, 123.10509
3606, -179.32893, 9.8169579, 127.68224
3607, -187.29166, 19.412398, 132.14643
3608, 37.867026, 40.396967, 191.31032
3609, 41.208328, 50.053576, 202.24749
3610, 28.60737, 42.518483, 201.05785
3611, 35.735418, 50.343391, 193.66125
3612, 23.13446, 42.808297, 192.47161
3613, 26.475762, 52.464907, 203.40878
3614, 14.958578, 47.373766, -284.53075
3615, 32.89045, 47.373766, -283.71418
3616, 11.545489, 32.431874, -284.60336
3617, 51.891821, 10.407661, 213.96522
3618, 46.615963, 8.5344503, 205.36359
3619, 59.348581, 14.035295, 202.99036
3620, 43.647672, 18.942112, 217.41083
3621, 56.380291, 24.442957, 215.0376
3622, 51.104433, 22.569745, 206.43598
3623, 142.78459, 30, 252.44692
3624, 122.77035, 30, 231.88659
3625, 152.80183, 30, 214.49132
3626, -24.387577, 10.975556, 172.05527
3627, -17.925143, 9.9212967, 183.37728
3628, -31.953311, 12.328413, 187.32407
3629, -12.533274, 20.896853, 168.52643
3630, -26.561442, 23.303969, 172.47323
3631, -20.099008, 22.24971, 183.79524
3632, -120.95966, 77.872935, -14.367521
3633, -122.59225, 77.872935, 3.3283139
3634, -119.67022, 53.260376, -27.585129
3635, -121.3028, 53.260376, -9.8892932
3636, 31.411414, 8.6743985, 247.53788
3637, 35.523584, 8.6743985, 239.69799
3638, 34.98142, 16.358961, 242.07336
3639, -84.682736, 14.115456, 186.57459
3640, -96.92453, 28.942774, 187.9149
3641, -73.782006, 30.336571, 202.53108
3642, -17.863564, 25.531829, -168.53278
3643, -0.76476933, 20.839156, -179.18138
3644, -8.0110086, 30.333678, -180.67733
3645, 114.75853, 30, 40.843991
3646, 119.91275, 58.881235, 22.404081
3647, 149.00223, 30, 30.764592
3648, 124.13293, 28.881235, 15.626237
3649, -197.2107, 34.983408, 122.97279
3650, -201.14922, 15.57101, 113.73578
3651, -188.57801, 30.778094, 104.69444
3652, -186.36394, 9.1371046, 42.204191
3653, -201.16275, 9.1371046, 44.475924
3654, -191.91255, 9.1371046, 55.190539
3655, -201.35334, 33.827262, 30.018551
3656, -195.58581, 33.312389, 23.613052
3657, -196.41442, 41.016091, 25.333676
3658, -109.00119, 44.827318, 156.13909
3659, -94.902874, 44.827318, 164.36437
3660, -108.38599, 44.827318, 173.36577
3661, 1273.9266, 15.083077, -23.920852
3662, -76.078816, 14.115456, 198.22712
3663, -58.513788, 16.221116, 193.484
3664, -102.8085, 44.115456, 192.72507
3665, -111.21302, 28.647935, 206.09929
3666, -122.67449, 44.532479, 191.55015
3667, -116.79052, 29.359798, 186.73999
3668, 56.179241, 330, -105.56298
3669, -71.76035, 46.221116, 178.98054
3670, -70.011227, 44.969919, 159.64337
3671, 464.67623, 30, 163.93892
3672, 465.01409, 30, 110.76607
3673, 425.18825, 30, 121.66616
3674, -227.53893, 10.00303, -39.052173
3675, -228.51083, 49.79238, -38.271851
3676, -237.94225, 50.142374, -37.638519
3677, -205.46719, 24.45281, 36.54147
3678, -203.20813, 16.632708, 34.739925
3679, -193.5644, 27.648662, 40.908486
3680, -199.09429, 26.007161, 28.217006
3681, -92.465139, 14.115456, 199.14281
3682, -98.042635, 14.827318, 179.78351
3683, -198.72637, 19.412398, 144.24858
3684, -202.4186, 19.636292, 155.38035
3685, -200.2041, 8.6845344, 146.46016
3686, -144.2733, 44.884204, 47.36049
3687, -152.02035, 46.319236, 28.294085
3688, -166.97743, 48.511557, 36.360863
3689, -151.78934, 31.203439, 37.318416
3690, -166.74643, 33.395761, 45.385194
3691, -174.49347, 34.830793, 26.318789
3692, -286.58862, 51.77336, -1.1595613
3693, -265.24967, 51.77336, -3.7259605
3694, -201.25645, 33.737537, 192.37303
3695, -198.1825, 24.17539, 194.42698
3696, -188.99672, 34.57177, 204.20343
3697, -185.92277, 25.009623, 206.25739
3698, 953.14893, 30, -117.52453
3699, -51.66251, 46.221116, 185.36112
3700, -49.913387, 44.969919, 166.02395
3701, -129.74579, 50.047062, 140.5338
3702, -119.5965, 45.197355, 124.38125
3703, -141.95914, 50.047062, 125.50519
3704, -131.80985, 45.197355, 109.35265
3705, -133.84195, 35.244417, 121.19247
3706, 1064.8044, 44.882206, 53.094035
3707, 1081.727, 44.258154, 53.68336
3708, 115.84458, 85.198152, 38.272101
3709, 94.215349, 85.198152, 74.138179
3710, 106.22362, 118.27163, 59.776499
3711, -25.735069, 15.097693, -164.51154
3712, -39.712622, 11.350802, -169.73554
3713, -34.961111, 15.097693, -154.03299
3714, -36.030035, 26.448495, -161.72481
3715, -48.938664, 11.350802, -159.25699
3716, 117.59998, 30, -32.335084
3717, 109.84779, 59.090832, -50.668067
3718, 118.30103, 58.881235, -19.744357
3719, 147.39052, 30, -11.383846
3720, 33.431827, 23.858872, 245.00437
3721, 35.965946, 23.846547, 236.13836
3722, -87.006665, 44.115456, 203.76325
3723, -92.584161, 44.827318, 184.40395
3724, -69.441637, 46.221116, 199.02013
3725, 1.5100604, 23.853216, -263.54098
3726, 2.7083866, 35.224232, -264.16944
3727, -6.8825429, 23.655059, -264.12567
3728, -5.6842167, 35.026075, -264.75413
3729, -5.3882893, 29.589736, -271.87416
3730, 57.048676, 243.70647, -107.95227
3731, 31.197657, 225.08542, -116.16327
3732, 63.26329, 211.20811, -103.35578
3733, 28.903675, 16.268071, 249.44693
3734, 934.09371, 30, 123.02351
3735, 954.34653, 30, 116.37514
3736, 265.0132, 30, -14.129445
3737, 232.8934, 30, 34.411705
3738, 218.33092, 30, -26.939775
3739, 607.10984, 30, -151.46631
3740, 571.90424, 30, -153.10233
3741, 7.8550601, 7.8555536, 263.4958
3742, 16.956033, 7.5936729, 261.36971
3743, -263.36604, 51.77336, 5.6006026
3744, -262.0327, 46.738885, 18.441561
3745, -271.9182, 38.512245, 9.5437353
3746, -285.25529, 46.738885, 11.681397
3747, -113.59037, 14.884204, 52.192411
3748, -117.27722, 39.65719, 43.314033
3749, -138.59863, 14.884204, 38.047806
3750, -111.83356, 24.772986, 24.977017
3751, 54.736359, 47.373766, -279.76704
3752, 43.821156, 47.373766, -263.7408
3753, 932.86361, 30, -123.21402
3754, 41.601694, 49.641141, 211.90256
3755, 35.635593, 42.194767, 217.348
3756, 43.733302, 39.694717, 209.55163
3757, 33.11062, 52.553627, 210.04387
3758, 35.242228, 42.607203, 207.69294
3759, 38.768603, 17.601707, -208.09516
3760, 33.166217, 7.5954931, -213.67014
3761, 32.326047, 18.030319, -200.65943
3762, 26.723661, 8.0241047, -206.23441
3763, 44.332191, 10.006214, -204.26887
3764, -119.02399, 40.445386, 7.5358702
3765, -125.02427, 41.092222, 24.247628
3766, -140.3454, 15.6724, 2.2696431
3767, -146.34568, 16.319236, 18.9814
3768, 14.551995, 52.668739, 261.53843
3769, 6.2497078, 52.889263, 265.92211
3770, -133.90177, 44.884204, 69.792507
3771, -144.9245, 45.207084, 94.013461
3772, -158.4216, 44.884204, 66.693556
3773, -155.06503, 30.091288, 80.605775
3774, -169.44433, 45.207084, 90.91451
3775, -153.38678, 9.9093623, 123.47205
3776, -37.394799, 48.944373, -245.44767
3777, -36.674716, 33.665325, -252.96696
3778, -41.916902, 49.624977, -235.68337
3779, -53.46658, 44.720952, -249.34004
3780, -41.196819, 34.345929, -243.20265
3781, 1259.5819, 45.751461, 51.054021
3782, 1271.5561, 45.751461, 20.136835
3783, 294.9239, 30, -58.51626
3784, 248.24162, 30, -71.32659
3785, -116.14161, 42.020718, 140.82678
3786, -130.38706, 32.06778, 137.638
3787, -118.74154, 30, -231.99136
3788, -114.15615, 30, -252.97206
3789, -96.131282, 30, -240.52738
3790, 6.1213609, 39.91929, 172.60552
3791, 17.389827, 31.148394, 170.18512
3792, 16.15811, 48.910768, 164.73088
3793, -20.538879, 50.480376, -284.68233
3794, -10.48644, 50.480376, -262.4415
3795, -15.399722, 34.735506, -271.93769
3796, -31.748637, 44.25513, -284.11739
3797, -21.696199, 44.25513, -261.87657
3798, 72.959738, 262.8228, 96.210735
3799, 59.124556, 220.34995, 107.07822
3800, 29.286556, 247.79161, 117.60605
3801, 813.16677, 30, 75.546631
3802, 1052.2132, 16.154972, -10.612397
3803, 1055.3407, 14.882206, 10.203374
3804, 76.652833, 215.98557, -94.930507
3805, 85.532053, 262.59785, -85.241711
3806, 212.07745, 30, -175.88678
3807, 273.41138, 30, -157.23475
3808, 247.67787, 30, -213.44408
3809, -153.0074, 45.207084, 109.24605
3810, -168.46654, 45.207084, 109.07513
3811, 56.871295, 79.120566, -107.09867
3812, 80.98684, 81.934623, -89.038253
3813, 64.529326, 109.46962, -103.9666
3814, -10.392977, 17.505925, -262.43513
3815, -1.7629894, 16.487938, -264.24675
3816, 679.94278, 30, -126.11001
3817, 652.99857, 30, -145.76997
3818, -165.38343, 35.006621, 118.36753
3819, -177.09923, 49.412398, 127.35348
3820, -167.76221, 49.799537, 122.61592
3821, 22.558844, 26.16481, -270.65834
3822, 25.926524, 17.373766, -284.29741
3823, 3.0766854, 23.849152, -285.42979
3824, 17.45772, 8.791044, -285.12384
3825, 179.59172, 30, -52.082916
3826, 186.12971, 30, 13.759295
3827, -181.12573, 48.511557, 55.693929
3828, -183.49338, 30.527983, 49.694684
3829, -199.27565, 38.079363, 43.388178
3830, -175.16856, 42.016426, 71.003047
3831, -190.95083, 49.567806, 64.69654
3832, -193.31848, 31.584232, 58.697296
3833, 1069.4232, 15.389611, -7.9599399
3834, 1064.1082, 31.544583, -12.667355
3835, 212.61788, 30, 87.202194
3836, 167.70663, 30, 113.71715
3837, 188.27665, 30, 147.31154
3838, -281.68249, 43.89049, 42.784865
3839, -277.0826, 43.89049, 65.508822
3840, -100.4481, 107.61959, -37.226023
3841, -122.06697, 131.90863, -53.253558
3842, -127.88202, 110.10548, -41.580124
3843, -105.60983, 120.68429, -61.888176
3844, -111.42488, 98.881144, -50.214743
3845, 1289.8795, 30, 83.876458
3846, 1304.4769, 30, 61.331837
3847, 136.74944, 30, -66.367492
3848, 800.79422, 30, 55.69413
3849, 33.141641, 35.22741, 204.87837
3850, -65.67326, 291.56055, 96.992345
3851, -54.362126, 330, 107.19738
3852, -93.106338, 321.56055, 79.386819
3853, -12.074478, 8.5390733, 262.27469
3854, -6.2459348, 16.117914, 265.68469
3855, -3.2895743, 7.8555536, 266.15029
3856, 1271.4081, 30, 99.169485
3857, 1250.2047, 30, 80.780527
3858, 1247.8798, 30, 114.24279
3859, -163.22569, 12.016426, 70.238779
3860, -160.78926, 26.90063, 60.694312
3861, -176.29293, 12.016426, 50.99039
3862, -146.47873, 14.884204, 65.929288
3863, -159.54597, 14.884204, 46.680899
3864, 492.44517, 30, -128.7979
3865, 526.55419, 30, -158.45876
3866, -28.509102, 9.0450936, 201.40416
3867, -35.902079, 9.0450936, 212.55421
3868, -22.243785, 7.787584, 194.76328
3869, -105.42669, 139.30415, -22.054351
3870, -110.58842, 152.36886, -46.716504
3871, -216.71557, 25.966259, -42.107456
3872, -199.73919, 21.590631, -27.055726
3873, -204.86661, 28.020835, -44.841826
3874, -221.59319, 35.990611, -44.187114
3875, -204.61681, 31.614983, -29.135384
3876, -87.881596, 45.912383, 119.72182
3877, -98.870034, 45.912383, 132.94576
3878, -84.771722, 45.912383, 141.17104
3879, -274.4418, 9.3148238, 8.9746396
3880, -271.25265, 16.738885, 20.337355
3881, -288.05241, 9.3148238, 5.4797531
3882, -284.86326, 16.738885, 16.842468
3883, -273.77402, 26.053709, 11.021979
3884, 1319.7058, 30, 32.981547
3885, -137.76467, 14.532479, 208.9396
3886, -155.83161, 13.521789, 213.4043
3887, -148.66881, 10.498104, 201.25879
3888, -149.14596, 28.054268, 209.38908
3889, -141.98316, 25.030583, 197.24358
3890, -160.0501, 24.019892, 201.70828
3891, 57.802867, 50.56986, -205.28064
3892, 50.122822, 50.56986, -219.57914
3893, 58.636358, 36.002182, -216.2761
3894, 70.067072, 45.432322, -211.83537
3895, 62.387027, 45.432322, -226.13387
3896, -10.389482, 17.708881, 191.23445
3897, -24.417651, 20.115997, 195.18124
3898, -195.56111, 12.204424, 69.092263
3899, -191.25579, 24.22085, 70.119328
3900, -201.32681, 21.341528, 61.333129
3901, -181.84153, 12.016426, 63.976737
3902, -187.60723, 21.153531, 56.217604
3903, 1176.9622, 30, 81.186836
3904, 1151.1419, 30, 80.812222
3905, 6.5101165, 52.764421, -194.16294
3906, 5.9455531, 42.663963, -185.18179
3907, 9.358891, 44.601752, -194.16294
3908, -1.7828083, 49.899542, -189.77105
3909, 1.0659663, 41.736872, -189.77105
3910, 5.0527292, 40.855525, 190.16789
3911, 13.67963, 41.375675, 191.90137
3912, 11.322515, 33.74742, 190.76624
3913, -25.803579, 50.608611, 187.66744
3914, -16.696548, 50.608611, 180.89574
3915, -33.826208, 50.608611, 176.69574
3916, -186.78891, 12.016426, 79.102643
3917, -171.81199, 27.22351, 84.915266
3918, -200.50849, 12.204424, 84.218168
3919, -181.06468, 15.207084, 99.014106
3920, -185.53157, 27.411508, 90.030792
3921, 763.89157, 30, -75.002084
3922, 780.68223, 30, -45.236357
3923, 795.38261, 30, -71.285274
3924, 1023.7895, 30, -125.56765
3925, 276.83418, 30, 198.01561
3926, 344.91886, 30, 184.82514
3927, 300.69288, 30, 133.76643
3928, 818.3116, 30, -75.669896
3929, -37.169656, 144.25959, 116.62118
3930, -54.857354, 152.61728, 107.83552
3931, -24.29599, 169.90987, 119.99529
3932, -157.50147, 15.207084, 90.150242
3933, -122.63555, 10.449765, 166.83696
3934, -106.40409, 14.827318, 163.67113
3935, -118.73348, 25.277083, 171.72144
3936, -128.61142, 10.449765, 182.09233
3937, -112.37996, 14.827318, 178.92649
3938, -31.691971, 10.975556, 158.79766
3939, -39.257706, 12.328413, 174.06646
3940, -92.370874, 30.739701, 145.36227
3941, -99.511302, 27.933101, 130.04996
3942, -109.64245, 26.848036, 153.24329
3943, -184.30857, 15.330311, -67.329703
3944, -177.67432, 15.330311, -81.229699
3945, -198.62948, 15.330311, -75.546085
3946, -46.25926, 14.720952, -258.62072
3947, -52.339162, 14.720952, -249.52955
3948, -61.452845, 14.720952, -259.28471
3949, -67.479226, 30.882303, 140.64128
3950, -70.723699, 45.912383, 129.68498
3951, -60.847118, 29.17502, 124.74865
3952, -55.963204, 44.969919, 148.15732
3953, -46.086623, 28.232556, 143.22098
3954, -49.331096, 43.262636, 132.26468
3955, -130.68424, 137.11366, -33.636405
3956, -117.66556, 25.087163, 160.84413
3957, -124.80599, 22.280563, 145.53182
3958, -117.40491, 35.305329, 162.15446
3959, -124.54534, 32.498729, 146.84215
3960, 65.488761, 102.32669, 103.39113
3961, 88.323945, 110.19752, 80.666137
3962, 64.71929, 131.7705, 103.89226
3963, 87.554474, 139.64134, 81.16727
3964, 384.20622, 30, 33.801405
3965, 425.58219, 30, 39.916173
3966, 421.17135, 30, 6.8959949
3967, 350.59655, 30, -0.19134847
3968, 334.36729, 30, 79.631659
3969, 1276.8015, 45.138231, 6.532523
3970, 829.41505, 30, -123.09423
3971, 870.54208, 30, -120.14274
3972, 109.36626, 247.48847, 52.804336
3973, -119.20569, 157.57389, -27.099351
3974, -187.77727, 39.176564, 22.728216
3975, -185.07615, 48.511557, 29.189133
3976, -183.40287, 50.665007, 17.531782
3977, -194.74113, 43.169541, 13.676326
3978, -192.04002, 52.504534, 20.137243
3979, -113.54452, 12.020718, 148.35882
3980, -88.210044, 14.827318, 150.6712
3981, -95.350473, 12.020718, 135.35889
3982, -157.37769, 50.250877, 202.47247
3983, -227.50011, 45.398317, 69.247563
3984, -223.05087, 30.969327, 84.560055
3985, -239.19143, 45.398317, 82.868308
3986, -215.51749, 45.57101, 89.249651
3987, -227.20881, 45.57101, 102.8704
3988, -192.6704, 49.412398, 126.11398
3989, -184.03771, 45.207084, 107.83563
3990, 1127.0073, 30, 119.65056
3991, 1148.7895, 30, 126.91644
3992, 48.889663, 13.153633, 148.17678
3993, 44.442136, 13.153633, 166.38073
3994, 57.707224, 13.153633, 168.6924
3995, 784.81613, 30, 24.894327
3996, 766.01789, 30, 11.696974
3997, 768.95942, 30, 49.909019
3998, 817.21546, 30, 141.1944
3999, 858.38986, 30, 138.1664
4000, -102.96619, 31.109738, 113.60443
4001, -66.729603, 75.273469, 102.10563
4002, -75.329418, 106.1749, 93.471361
4003, 807.32433, 30, -50.995761
4004, 69.185316, 288.64962, -92.481936
4005, 99.008218, 289.94742, -71.969489
4006, -212.47105, 42.204424, 74.586006
4007, -214.53374, 49.567806, 63.163974
4008, -188.88814, 42.204424, 76.118573
4009, -207.03806, 31.77223, 63.812822
4010, -121.56763, 10.259845, 155.95966
4011, 44.212476, 50.343391, 182.91266
4012, 44.865012, 50.343391, 160.29003
4013, 45.06941, 33.497024, 176.03968
4014, 57.540306, 43.153633, 153.60563
4015, 48.998758, 20.139175, -210.81871
4016, 48.153365, 30.576074, -204.20763
4017, 37.351083, 25.364346, -205.42079
4018, 47.217547, 30.702821, -216.33245
4019, 36.415265, 25.491093, -217.54562
4020, 35.569871, 35.927992, -210.93454
4021, 80.205943, 44.93582, 224.51541
4022, 74.623973, 44.035295, 208.1395
4023, 69.419022, 28.971116, 220.43867
4024, 67.322239, 44.93582, 229.30368
4025, 61.740269, 44.035295, 212.92776
4026, 987.67287, 30, -122.68205
4027, 973.63174, 30, -83.585708
4028, 34.784934, 52.602352, 229.65145
4029, 894.38154, 30, -125.60983
4030, 133.82378, 30, -187.86154
4031, 144.30018, 30, -143.14664
4032, 105.89093, 30, -167.78425
4033, -269.04151, 13.89049, 33.514238
4034, -268.37372, 30.629375, 35.561577
4035, -283.19958, 16.738885, 35.456027
4036, 49.685386, 50.053576, 191.4989
4037, 50.54232, 33.207209, 184.62592
4038, 53.588494, 34.088872, 201.97966
4039, 25.61294, 50.343391, 165.30113
4040, 24.592937, 50.343391, 182.01023
4041, 22.939286, 39.254159, 182.15383
4042, 15.138108, 48.910768, 181.43998
4043, 7.5404419, 48.910768, 190.16789
4044, 5.2643581, 39.398321, 181.75892
4045, -0.67965652, 50.487553, 190.34323
4046, -3.1673692, 42.43231, 190.34323
4047, 417.15528, 30, -181.19652
4048, 477.21952, 30, -173.37793
4049, 443.85469, 30, -141.57569
4050, 1274.7329, 45.083077, -8.5207428
4051, 1293.748, 30, -9.5623297
4052, 1288.2687, 30, -36.971943
4053, 24.398453, 53.856006, 119.27489
4054, 43.650525, 53.856006, 114.26379
4055, 34.679464, 69.925252, 117.45072
4056, -44.817146, 44.720952, -276.86068
4057, -63.648198, 44.720952, -273.3502
4058, -50.135456, 44.720952, -260.18022
4059, 33.914273, 52.553627, 220.95539
4060, 773.33496, 30, -97.500213
4061, 804.826, 30, -93.783403
4062, -200.48695, 9.7291129, -146.38179
4063, 36.878284, 34.813289, 222.79259
4064, 46.525099, 30.048802, 222.60957
4065, 41.249241, 28.175591, 214.00795
4066, 39.276716, 25.579809, 226.19547
4067, 34.000857, 23.706598, 217.59385
4068, 4.9102526, 21.055019, -188.2751
4069, -2.3359867, 30.549541, -189.77105
4070, -7.9996237, 21.084135, -189.65848
4071, 82.061906, 45.432322, -230.12302
4072, -16.823777, 8.3965647, -263.33416
4073, -23.028848, 14.25513, -272.20825
4074, -26.985681, 8.3965647, -257.00334
4075, -20.404409, 22.651695, -262.49866
4076, -33.190752, 14.25513, -265.87743
4077, -193.7656, 41.822603, -41.760672
4078, -210.74199, 46.198231, -56.812402
4079, -210.49218, 49.79238, -41.10596
4080, 1275.9952, 15.138231, -8.8675858
4081, 1277.4398, 15.138231, 16.107795
4082, 48.685265, 30, 132.42712
4083, 39.315553, 42.237625, 148.32132
4084, 30.66491, 12.237625, 142.89246
4085, 39.519951, 25.391258, 164.07097
4086, -196.88923, 41.574137, -100.93051
4087, -197.05558, 45.330311, -82.676966
4088, -187.66267, 50.523139, -100.682
4089, -190.55698, 26.904448, -92.843574
4090, -181.16407, 32.097276, -110.84861
4091, -181.33042, 35.85345, -92.595065
4092, 109.94388, 150.07737, 46.551093
4093, 121.84547, 154.26935, 9.189656
4094, -187.82627, 11.574137, -112.9457
4095, -177.50798, 11.574137, -99.483245
4096, -198.46314, 11.574137, -93.799631
4097, 1268.6209, 30, 68.874858
4098, -28.513206, 44.808661, 281.94884
4099, -44.940197, 14.808661, 279.79532
4100, -49.826708, 44.808661, 279.15472
4101, -233.42292, 54.235947, 37.799069
4102, 93.231062, 16.273815, 146.19891
4103, 76.069398, 13.153633, 156.44212
4104, 66.051327, 16.273815, 137.93357
4105, 74.906368, 29.427448, 159.11208
4106, 74.70197, 46.273815, 143.36243
4107, 32.436993, 9.5608389, 174.9847
4108, 45.739562, 22.714472, 177.95926
4109, 45.702081, 9.5608389, 177.29637
4110, 118.12521, 122.46361, 22.415063
4111, 120.1833, 126.84997, -11.622015
4112, -54.991045, 46.221116, 212.62495
4113, -72.556073, 44.115456, 217.36807
4114, 1006.722, 13.830788, -56.54792
4115, 1031.3536, 13.830788, -37.619756
4116, 1014.1157, 43.830788, -30.917229
4117, 1009.9955, 30, -63.458308
4118, 1034.6271, 30, -44.530144
4119, 709.35277, 30, 142.26079
4120, 721.19138, 30, 102.67136
4121, 762.03481, 30, 136.78178
4122, 997.68082, 13.830788, -26.564004
4123, -132.60099, 111.21112, -21.854117
4124, 1129.3596, 30, 73.546342
4125, 1114.8196, 30, -82.437757
4126, 1129.2483, 30, -105.82412
4127, -132.9753, 138.00867, -10.059415
4128, -122.29556, 126.45964, 5.9614893
4129, -106.22549, 107.2949, -12.5705
4130, -121.92125, 99.662089, -5.833212
4131, -226.54635, 26.201262, -44.575918
4132, -214.18932, 16.198231, -68.197849
4133, -222.83558, 16.198231, -54.369811
4134, -212.30126, 16.198231, -51.695436
4135, 2.0723361, 30, 274.82461
4136, -1.7408223, 30, 287.02362
4137, 6.6298839, 30, 286.94703
4138, 1017.4969, 13.830788, -12.231889
4139, 999.47127, 13.830788, -4.7890279
4140, 10.144326, 8.791044, -273.82913
4141, 23.965504, 8.791044, -269.6861
4142, 14.057511, 8.791044, -262.59665
4143, -81.934192, 15.458048, -117.15647
4144, -48.074287, 15.458048, -129.26957
4145, -78.997439, 15.458048, -136.13822
4146, 1000.0054, 43.830788, -15.160485
4147, -258.14697, 8.332644, 21.320977
4148, -249.7902, 8.332644, 32.784458
4149, -163.51924, 8.9399017, -98.446753
4150, -156.95348, 8.9399017, -112.16489
4151, -173.83753, 8.9399017, -111.90921
4152, 993.82118, 43.830788, -35.24762
4153, -50.722981, 30, 231.72443
4154, -51.948914, 16.221116, 216.88744
4155, -38.454829, 19.394548, 230.30406
4156, -41.496961, 49.394548, 226.04156
4157, -42.722893, 35.615663, 211.20457
4158, 989.70099, 30, -67.788699
4159, -153.88431, 49.542988, -198.40551
4160, -165.10558, 49.175359, -201.0568
4161, 6.9180093, 50.487553, 181.61532
4162, -7.8456608, 51.008522, 155.99969
4163, 7.7750121, 51.008522, 172.46192
4164, 124.72873, 49.634182, -211.29288
4165, 122.03507, 30, -207.36999
4166, 96.795884, 49.634182, -191.21559
4167, 93.038947, 19.634182, -207.91435
4168, 94.102226, 30, -187.29271
4169, 104.78491, 30, -140.0628
4170, 81.825038, 42.44136, -138.58076
4171, 90.962821, 12.44136, -163.49253
4172, 82.931055, 42.44136, -166.30222
4173, 61.819553, 49.955764, -189.52099
4174, 70.919071, 46.988911, -198.10599
4175, 50.388839, 40.525624, -193.96172
4176, 59.488358, 37.558772, -202.54673
4177, 63.505044, 36.944676, -186.78708
4178, 43.181312, 44.980749, 256.58459
4179, 44.384135, 34.823805, 253.30354
4180, 57.83027, 44.980749, 259.35139
4181, 44.578069, 49.843056, 243.06419
4182, 59.227026, 49.843056, 245.831
4183, -126.83012, 51.490589, -140.23906
4184, 170.54555, 30, -191.77226
4185, 139.19564, 30, -216.50178
4186, 61.255357, 14.980749, 259.23925
4187, 60.912664, 8.6743985, 248.7764
4188, 77.262164, 14.93582, 244.23458
4189, 42.644685, 23.655147, 256.36108
4190, 58.994185, 29.916569, 251.81926
4191, 58.651492, 23.610219, 241.35641
4192, -263.73482, 7.2482129, 14.246409
4193, 26.217382, 12.237625, 161.09642
4194, 27.514808, 21.798464, 172.67494
4195, -265.24967, 43.891331, 0.8906354
4196, 58.98943, 10.006214, -186.28751
4197, 55.751485, 10.006214, -203.35011
4198, 70.139933, 10.006214, -201.34268
4199, 23.539773, 13.81729, 128.95413
4200, 32.190416, 43.81729, 134.38299
4201, -193.74529, 16.135541, -8.4470084
4202, -192.64141, 8.0407122, -3.073924
4203, -185.1858, 8.0407122, -10.1706
4204, -192.40046, 8.0948287, -12.983659
4205, -103.44984, 30, 65.600096
4206, -123.72695, 45.197355, 94.120058
4207, -103.41555, 15.197355, 76.519962
4208, -133.86748, 30.081559, 80.712373
4209, 62.667132, 286.37053, 99.886007
4210, 18.99395, 271.33933, 121.28132
4211, -82.689081, 15.912383, 85.084473
4212, -70.316981, 41.811759, 98.697011
4213, -91.043451, 41.096731, 90.1325
4214, -120.89832, 190.74891, -17.188091
4215, -111.38231, 184.98055, -45.542806
4216, -40.630827, 45.097693, -164.1856
4217, -45.491455, 51.008748, -179.90706
4218, -20.30189, 45.097693, -168.08827
4219, -26.913111, 36.106441, -172.22226
4220, -25.162519, 51.008748, -183.80973
4221, 78.352091, 30, -94.135225
4222, 62.776501, 56.276775, -102.92678
4223, 86.892046, 59.090832, -84.866367
4224, 45.619041, 17.373766, -281.49124
4225, -15.914435, 49.93515, -190.80363
4226, -7.8124723, 39.834692, -191.36072
4227, -22.525656, 40.943898, -194.93763
4228, -10.449335, 49.899542, -180.23282
4229, -17.060556, 40.90829, -184.36681
4230, 49.774404, 49.955764, -185.93509
4231, 49.385771, 49.955764, -173.95093
4232, 122.50607, 30, 206.21807
4233, 109.90635, 15.516866, 189.61867
4234, 117.674, 30, 177.82475
4235, 106.02663, 45.516866, 213.372
4236, 101.19456, 45.516866, 184.97867
4237, 11.848388, 23.5349, -263.66051
4238, 3.7517122, 17.900404, -271.36523
4239, 4.9500385, 29.27142, -271.99369
4240, -61.012849, 268.44356, 97.61154
4241, 94.755404, 178.44706, 66.724308
4242, 1260.3741, 44.506122, -47.727248
4243, 1266.8948, 30, -40.64275
4244, 37.632799, 9.2678874, -256.65966
4245, 36.226139, 26.641653, -257.6319
4246, 30.980801, 16.557622, -247.2946
4247, 32.434308, 17.373766, -268.85967
4248, 27.18897, 7.2897345, -258.52237
4249, 25.782309, 24.6635, -259.49461
4250, 33.77452, 30.165223, 255.46723
4251, 29.246368, 22.574422, 259.90978
4252, 26.625769, 30.516689, 261.17179
4253, 33.535007, 34.814974, 214.53344
4254, -35.422015, 48.75123, 205.08751
4255, -53.006602, 46.221116, 200.23985
4256, -39.512518, 49.394548, 213.65647
4257, -38.63239, 34.972346, 202.63561
4258, -117.50823, 54.772986, 34.289702
4259, 30.65758, 23.708284, 209.3347
4260, 40.855875, 28.588027, 204.35288
4261, -224.86638, 12.204424, 75.789672
4262, -208.02181, 27.775434, 89.898499
4263, -203.55493, 15.57101, 98.881813
4264, -227.91282, 15.57101, 90.453317
4265, 35.652218, 8.5344503, 200.09006
4266, 33.333521, 9.5608389, 188.96707
4267, 44.297265, 9.5608389, 194.2406
4268, 36.053117, 18.095289, 197.68622
4269, -196.74143, 15.330311, -59.043672
4270, -63.318397, 14.969919, 145.95021
4271, -23.665793, 45.097693, -151.82627
4272, -157.40208, 24.529621, -9.3756982
4273, -163.40236, 25.176457, 7.3360592
4274, -150.21165, 8.8572212, 8.0654489
4275, -102.24678, 15.912383, 120.36518
4276, 26.844656, 32.581016, 170.75536
4277, 23.609438, 28.471607, 184.07341
4278, -263.06703, 23.987098, 16.293748
4279, -257.47918, 25.071529, 23.368316
4280, -175.55465, 8.8572212, -9.1435715
4281, -162.9713, 8.8572212, -8.3328634
4282, -172.37225, 8.8572212, -1.8878071
4283, -140.10441, 30, -40.242086
4284, -140.68553, 15.6724, -31.735114
4285, -149.39189, 15.031952, -48.0089
4286, -146.95471, 45.6724, -23.678476
4287, -155.66106, 45.031952, -39.952261
4288, -156.24219, 30.704352, -31.445289
4289, 1066.5917, 15.389611, -30.623785
4290, 1049.3816, 16.154972, -33.276242
4291, 1004.741, 30, 14.083419
4292, 1016.1119, 43.830788, -5.1343941
4293, -263.91633, 38.856856, 13.731594
4294, -259.06127, 39.454089, 22.10664
4295, -16.05614, 223.89588, 118.01645
4296, 16.889963, 224.10572, 121.50172
4297, -3.4903345, 194.09411, 121.11785
4298, 1064.1817, 14.882206, 55.46885
4299, 1035.4896, 44.882206, 51.875866
4300, 1046.5181, 30, 81.032986
4301, -75.091892, 44.308033, -209.7505
4302, -81.674229, 44.608369, -193.7454
4303, -61.995571, 28.916402, -201.80398
4304, -49.875832, 44.308033, -209.36973
4305, -56.458168, 44.608369, -193.36463
4306, -15.339589, 276.88301, 121.89632
4307, -201.70296, 48.829341, -35.407954
4308, -204.57989, 31.996998, -96.666078
4309, -210.91214, 46.666687, -104.75302
4310, -204.41354, 28.240825, -114.91962
4311, 3.6543614, 248.22235, 121.90051
4312, -244.23827, 50.142374, -44.873634
4313, -246.76234, 50.142374, -32.541485
4314, -53.423025, 14.308033, -219.96346
4315, -64.647371, 14.308033, -225.76206
4316, -66.93824, 14.308033, -213.36328
4317, 60.390941, 34.778877, 238.29886
4318, 73.837077, 44.93582, 244.34671
4319, -75.958855, 55.899376, 96.249888
4320, -108.60807, 45.197355, 111.15731
4321, -11.619586, 77.184732, 121.7094
4322, -2.2207407, 94.321052, 122.34375
4323, 5.0210897, 77.184732, 121.46252
4324, 50.241092, 15.187361, -261.64442
4325, 54.032924, 24.455249, -250.41665
4326, 67.389381, 15.187361, -249.36222
4327, 54.781088, 9.2678874, -244.37747
4328, -81.346047, 14.308033, -225.07305
4329, 174.59236, 30, 231.76284
4330, 23.971556, 18.263829, -192.07752
4331, 26.142189, 10.239724, -183.80864
4332, 36.640809, 10.239724, -184.88632
4333, 16.888151, 8.0241047, -194.35609
4334, 27.386771, 8.0241047, -195.43378
4335, 1314.9314, 30, -41.055156
4336, 1320.3711, 30, -22.240791
4337, 74.479709, 144.29366, -96.857468
4338, 97.138636, 154.01235, -72.508087
4339, 87.188253, 119.1883, -79.617221
4340, 324.98768, 30, -143.78129
4341, 389.90646, 30, -146.09781
4342, 358.71115, 30, -188.76955
4343, 60.257354, 45.187361, -242.41916
4344, 49.109164, 50.254406, -234.60671
4345, 61.62794, 45.187361, -256.52555
4346, 55.493027, 35.441768, -247.58895
4347, 50.479751, 50.254406, -248.7131
4348, 220.4379, 30, 218.53857
4349, 88.460972, 44.93582, 260.53496
4350, 72.454166, 44.980749, 275.53964
4351, -209.17797, 49.521316, -176.11886
4352, -213.15169, 19.521316, -171.22811
4353, -208.37693, 39.569068, -183.20465
4354, -212.35065, 9.5690683, -178.3139
4355, 90.409341, 15.516866, 206.81162
4356, 110.17062, 15.516866, 215.28719
4357, -126.30394, 50.395143, -174.97593
4358, -132.02794, 49.542988, -184.12852
4359, 268.63783, 30, 94.180055
4360, 244.2966, 30, 154.2894
4361, -61.814643, 44.308033, -219.39136
4362, -21.437837, 38.847304, -124.93104
4363, -5.3553098, 53.749611, -121.11093
4364, -23.051148, 53.749611, -120.25651
4365, -5.9699553, 45.097693, -152.6807
4366, 1032.1437, 46.154972, -26.573715
4367, 1028.8701, 29.98576, -19.663327
4368, 55.865536, 330, 105.84514
4369, -248.86245, 10.288229, -42.264474
4370, -239.83367, 10.00303, -46.68492
4371, -38.410004, 49.394548, 238.93629
4372, -253.05432, 30, -112.54856
4373, -246.88164, 46.666687, -117.95287
4374, -241.04603, 30, -98.881227
4375, -224.60914, 16.666687, -113.33782
4376, -234.87335, 46.666687, -104.28554
4377, -202.25537, 49.521316, -155.73142
4378, 1188.1346, 30, 125.71956
4379, -192.64141, 15.250375, 0.2601947
4380, -192.64141, 22.139678, -3.9394739
4381, -23.193678, 9.973102, -186.54973
4382, -32.858449, 9.973102, -191.09452
4383, -31.937542, 9.973102, -180.478
4384, 48.785735, 23.596134, 195.31299
4385, 38.537178, 29.614415, 193.22989
4386, -146.40787, 8.9399017, -101.89394
4387, -4.8406923, 9.1093603, -264.24675
4388, -13.017416, 9.1093603, -272.14472
4389, -60.755785, 15.458048, -143.1967
4390, -47.847156, 30.555741, -145.66452
4391, -61.824709, 26.80885, -150.88852
4392, -34.063675, 48.944373, -256.28784
4393, -28.254956, 25.070795, -172.46727
4394, -42.232508, 21.323904, -177.69128
4395, 1067.4885, 14.882206, 20.083694
4396, -174.46136, 27.348138, -6.2385916
4397, 54.815667, 10.132961, -215.47493
4398, 66.234478, 15.432322, -215.41858
4399, 58.100243, 10.132961, -233.13328
4400, 59.481751, 25.565283, -222.88718
4401, 69.519054, 15.432322, -233.07694
4402, -22.724193, 31.442884, -184.25424
4403, -34.361582, 157.47168, -115.57107
4404, -58.970337, 173.99179, -106.98786
4405, -31.443171, 185.01391, -115.63941
4406, 39.127009, 16.953022, -139.16666
4407, 33.467003, 46.953022, -147.81496
4408, 44.5951, 29.394382, -157.86459
4409, 51.406759, 30, -133.26292
4410, 62.534856, 12.44136, -143.31255
4411, 56.87485, 42.44136, -151.96085
4412, -16.903003, 19.627012, -193.44942
4413, -16.030644, 9.1928761, -195.4999
4414, -27.294395, 19.165978, -197.38391
4415, -12.802287, 10.434136, -182.61524
4416, -24.066037, 20.407238, -184.49925
4417, -59.489264, 14.608369, -182.84668
4418, -59.292748, 25.959171, -176.37384
4419, -51.517668, 24.581471, -187.11631
4420, -50.204104, 11.350802, -173.42165
4421, -42.429024, 9.973102, -184.16412
4422, -126.13858, 51.57172, 178.80817
4423, -129.12792, 10.210557, -181.41747
4424, -134.6074, 19.542988, -189.34086
4425, -116.80567, 16.123108, -181.87601
4426, -120.46214, 26.333664, -169.54175
4427, -125.94163, 35.666096, -177.46514
4428, 81.474926, 16.988911, -199.68178
4429, 84.168583, 36.623093, -203.60466
4430, 85.231863, 46.988911, -182.98302
4431, 0.18203031, 40.702633, -123.53999
4432, 20.009222, 56.276775, -119.78156
4433, 25.546562, 43.229797, -122.21061
4434, 15.649912, 46.953022, -151.28964
4435, -195.82758, 30.651944, -23.437378
4436, -194.42509, 19.917432, -20.525082
4437, 4.6296248, 7.3785779, -266.71065
4438, 8.5753384, 16.169622, -264.36628
4439, -0.19400137, 9.1093603, -273.7096
4440, -41.127556, 9.0343648, -211.69534
4441, -54.453292, 14.308033, -209.31241
4442, -40.097289, 9.0343648, -222.34638
4443, -42.087499, 23.342398, -220.192
4444, -226.31241, 16.198231, -83.913533
4445, -236.57662, 46.198231, -74.86125
4446, -220.13973, 32.864919, -89.317842
4447, -109.04268, 78.197626, -56.307846
4448, -115.18227, 78.197626, -39.023045
4449, 92.747471, 31.790681, 172.82073
4450, 109.22691, 16.273815, 165.66681
4451, 88.887287, 16.273815, 166.22114
4452, 89.566725, 15.516866, 190.173
4453, -50.442127, 127.95624, 110.53772
4454, -79.744646, 130.83594, 90.769165
4455, -173.75943, 33.231117, 198.85444
4456, -163.73053, 33.772666, 202.44036
4457, -170.68548, 23.66897, 200.90839
4458, -182.99476, 11.822603, -31.862763
4459, -195.32488, 11.822603, -36.643706
4460, -182.89202, 11.822603, -44.929737
4461, -249.86394, 30, -76.970252
4462, -235.13032, 16.198231, -62.002559
4463, -78.078892, 15.912383, 127.47787
4464, -56.686288, 13.262636, 130.05758
4465, -86.001903, 44.115456, 227.3181
4466, -99.725436, 14.115456, 218.46577
4467, -104.86328, 44.115456, 214.87122
4468, -94.380305, 30, 238.50966
4469, -113.24169, 30, 226.06279
4470, -120.21763, 36.518251, -168.31255
4471, -114.22621, 46.123108, -176.66367
4472, -123.90407, 50.47801, 149.73795
4473, 1048.3211, 46.154972, -41.536821
4474, 1064.978, 46.154972, -38.494032
4475, 1051.8095, 46.154972, -20.537537
4476, -275.10735, 31.088184, -1.8189798
4477, -263.91633, 30.559313, 10.253117
4478, -265.24967, 35.593788, -2.5878411
4479, 28.758745, 36.337822, -199.63671
4480, 27.08363, 43.813319, -197.53619
4481, 22.928532, 36.709591, -194.4876
4482, -78.614019, 73.21577, -92.728021
4483, -68.815456, 91.888205, -101.29002
4484, -84.674845, 91.24383, -86.359592
4485, 1050.8046, 30, -59.493251
4486, -125.36479, 12.020718, 143.50412
4487, -220.00443, 27.602741, 69.896411
4488, -239.89543, 15.398317, 70.451228
4489, -145.8113, 19.542988, -200.61342
4490, -157.03258, 19.175359, -203.26471
4491, -147.98597, 8.9940907, -202.06649
4492, -188.2848, 51.926934, -3.4255975
4493, -181.96069, 50.665007, 2.2008801
4494, -192.42809, 42.591941, 5.444388
4495, -192.42809, 50.665007, 7.7061047
4496, 4.4572735, 49.899542, -179.94378
4497, 16.224586, 46.953022, -166.40818
4498, 17.712865, 39.717444, -171.64619
4499, 12.750198, 52.764421, -184.33567
4500, -136.78207, 8.9940907, -190.79394
4501, 998.46797, 30, 45.105399
4502, -201.57006, 9.851561, 159.64628
4503, -244.05338, 30, 88.76157
4504, -237.91481, 30, 107.7296
4505, -221.77425, 15.57101, 109.42135
4506, 14.335434, 15.53594, 262.63173
4507, 3.1907998, 15.53594, 265.28622
4508, 17.199188, 15.53594, 277.10608
4509, -139.56771, 14.532479, 232.83476
4510, -155.02748, 14.480576, 231.03565
4511, 26.968577, 37.932713, -170.42221
4512, 13.191792, 33.169441, -183.68584
4513, 23.494189, 43.744112, -188.3497
4514, 22.447504, 31.38471, -182.46186
4515, -182.2501, 18.511557, 35.681272
4516, 13.703243, 45.53594, 277.18046
4517, 18.117017, 10.40502, -167.95695
4518, 0.35224047, 10.40502, -167.59895
4519, 8.2370817, 10.40502, -176.86304
4520, -61.035629, 14.608369, -193.30731
4521, -43.975389, 9.973102, -194.62474
4522, -80.311665, 14.115456, 231.27402
4523, -74.966534, 30, 251.31792
4524, -33.734732, 34.203209, 244.64187
4525, -42.960753, 14.808661, 250.32473
4526, -33.48521, 24.123799, 249.1139
4527, -38.205308, 9.3151381, 234.77609
4528, -64.061247, 16.221116, 208.76623
4529, -62.835314, 30, 223.60322
4530, -81.626275, 14.115456, 213.50935
4531, -43.422954, 27.298332, 173.42782
4532, -48.553483, 14.969919, 159.75225
4533, -56.764665, 14.969919, 174.14683
4534, -47.468887, 12.328413, 188.46104
4535, -6.6393702, 24.104806, 189.42849
4536, 1.5448664, 24.757949, 189.89867
4537, -1.7484724, 17.19376, 189.30032
4538, 38.406314, 44.980749, 269.42498
4539, 27.206423, 27.192747, -167.62438
4540, 32.987748, 31.219415, -184.3279
4541, 22.685351, 20.644744, -179.66403
4542, -59.448714, 44.808661, 256.01227
4543, -46.002884, 44.808661, 246.06224
4544, -53.758476, 14.808661, 259.96819
4545, -61.520704, 30, 241.36789
4546, -206.8138, 49.412398, 139.40821
4547, -193.27335, 49.412398, 140.93504
4548, -41.727868, 25.266209, 206.84508
4549, -30.985554, 34.653876, 254.90768
4550, -42.915927, 44.808661, 258.95697
4551, -35.660826, 49.845215, 249.20211
4552, -170.11907, 46.319236, 21.122355
4553, 1067.4615, 30, -56.450462
4554, -240.25096, 49.743013, 42.976825
4555, -234.38767, 45.398317, 55.660527
4556, -230.50819, 47.530501, 44.424636
4557, -240.89677, 35.14133, 51.874265
4558, -237.01729, 37.273513, 40.638375
4559, -231.15401, 32.928818, 53.322076
4560, -191.89383, 7.4956039, 29.512711
4561, -206.69263, 7.4956039, 31.784445
4562, -39.346288, 12.328413, 198.47412
4563, -50.391188, 16.221116, 203.49708
4564, -45.172077, 28.549529, 192.76499
4565, 85.260803, 325.60927, 85.87004
4566, 108.55094, 325.60927, 54.624538
4567, -111.5375, 75.62188, 49.775271
4568, -104.07836, 107.6497, 63.631917
4569, -114.0543, 98.721828, 36.378851
4570, -251.9221, 52.715204, 29.912504
4571, -263.4457, 46.738885, 30.190559
4572, -272.29655, 30, -74.646911
4573, -266.39015, 30, -95.784985
4574, -261.60112, 31.853429, 19.337748
4575, -196.96558, 49.636292, 152.06681
4576, -210.50603, 49.636292, 150.53998
4577, -239.57904, 16.666687, -132.74846
4578, -131.63941, 89.421964, -30.388426
4579, -225.91046, 25.842736, 35.648961
4580, -220.60133, 17.187552, 37.166597
4581, -220.26533, 32.846206, 33.868861
4582, -221.96539, 26.405817, 43.603822
4583, -214.9562, 24.191022, 35.386497
4584, -107.00398, 194.62555, 56.802808
4585, -84.668163, 191.56938, 87.306704
4586, -171.42118, 15.031952, -53.894226
4587, -189.30678, 27.152914, -52.190062
4588, -176.41938, 26.854556, -38.754585
4589, -177.83593, 30.362263, -61.154551
4590, 153.30896, 30, -103.64963
4591, 196.15124, 30, -89.365054
4592, -85.629465, 326.66285, -85.317623
4593, -102.15008, 288.70654, -67.381824
4594, -55.633073, 330, -106.05423
4595, -72.153691, 292.04369, -88.118428
4596, -98.199596, 30, -102.05512
4597, -119.57174, 45.809981, -103.07152
4598, -86.931365, 53.082399, -86.335946
4599, -111.5987, 15.809981, -100.50111
4600, -78.958324, 23.082399, -83.765537
4601, -100.33047, 38.89238, -84.78193
4602, -187.06126, 41.822603, -31.006311
4603, -182.29476, 45.031952, -50.725161
4604, -175.59041, 45.031952, -39.9708
4605, -133.96482, 30, -57.526887
4606, -149.52147, 45.031952, -57.237062
4607, -36.812355, 9.1928761, -203.57491
4608, -120.07545, 54.772986, 16.724734
4609, -154.58757, 46.319236, 10.729117
4610, -50.148016, 44.308033, -220.56056
4611, -205.62373, 23.87977, 186.53491
4612, -120.02503, 77.872935, 20.893282
4613, -121.35083, 99.103312, 14.346189
4614, -0.65974633, 16.953022, -138.7148
4615, 22.63809, 16.953022, -155.9173
4616, 6.3176625, 50.480376, -272.94722
4617, -2.650227, 50.480376, -285.86611
4618, 13.418842, 37.854142, -271.16727
4619, 23.926468, 47.373766, -271.61186
4620, -148.58729, 45.6724, -5.9826403
4621, 17.313506, 16.080779, -260.32103
4622, -187.21043, 19.863316, -17.712022
4623, -193.32121, 25.92157, -16.017548
4624, -184.7723, 30.31352, -19.343693
4625, -184.0925, 26.531629, -7.2656198
4626, -190.20329, 32.589883, -5.571145
4627, -95.081796, 78.197626, -75.243088
4628, -100.89225, 53.082399, -67.400704
4629, -197.16703, 24.095262, -194.97792
4630, -199.22061, 9.5690683, -193.11462
4631, -189.68671, 24.035744, -202.82918
4632, -191.74029, 9.5095505, -200.96588
4633, -34.760835, 53.141512, -217.64917
4634, -34.488651, 53.141512, -206.45834
4635, -70.19847, 44.308033, -233.26341
4636, -54.079866, 29.028985, -237.3342
4637, -54.799948, 44.308033, -229.81492
4638, -68.865101, 44.720952, -252.78854
4639, 18.505032, 37.673296, 110.7908
4640, 7.7639033, 13.81729, 112.8966
4641, 34.999881, 23.856006, 108.83493
4642, 40.811856, 144.95985, 114.02576
4643, 3.1177986, 146.97414, 119.17873
4644, 11.632649, 115.57672, 120.65754
4645, -51.46277, 14.720952, -275.98946
4646, -79.432606, 30, -241.21639
4647, -63.314003, 14.720952, -245.28718
4648, 38.13713, 35.666793, -218.64624
4649, 37.592484, 43.210343, -216.25999
4650, 94.477927, 49.634182, -224.62623
4651, 83.316584, 35.066504, -217.33403
4652, 82.483093, 49.634182, -206.33857
4653, -192.33545, 10.147181, 200.43888
4654, 152.53756, 30, 188.8228
4655, 167.80831, 30, 156.75116
4656, 188.37833, 30, 190.34555
4657, -215.17235, 16.666687, -130.5588
4658, -131.05417, 30, -197.94963
4659, -110.121, 30, -197.72183
4660, -122.38839, 46.123108, -186.07391
4661, -101.45522, 46.123108, -185.84611
4662, 1093.5745, 30, -54.547805
4663, 1082.188, 45.389611, -35.841575
4664, -136.30392, 15.197355, 90.25684
4665, -25.695415, 9.1928761, -200.04469
4666, -97.579911, 132.50905, 73.882871
4667, -91.480084, 107.48508, 80.753487
4668, -58.800959, 55.899376, 106.21305
4669, -27.87395, 49.845215, 259.24575
4670, -35.129052, 44.808661, 269.00061
4671, -20.796087, 39.359841, 193.97023
4672, -27.587489, 31.079643, 197.61264
4673, -13.876136, 34.79212, 189.73286
4674, -20.667538, 26.511922, 193.37528
4675, -27.335774, 32.937024, 184.09961
4676, -166.88406, 45.6724, -23.697015
4677, -183.94333, 48.490917, -20.559908
4678, 63.425826, 15.187361, -274.27598
4679, 75.614413, 14.035295, 210.45669
4680, 81.196383, 14.93582, 226.83261
4681, 61.962261, 25.343482, 231.41352
4682, 68.157652, 10.407661, 221.43155
4683, 32.314309, 47.373766, -265.54959
4684, -116.22574, 185.5009, 19.972503
4685, 122.15324, 44.597603, -261.34694
4686, 93.485255, 44.597603, -267.99843
4687, 100.87434, 44.597603, -241.85496
4688, -142.23232, 15.809981, -108.41158
4689, -152.25634, 10.503563, -124.07869
4690, -142.99486, 26.313544, -117.18461
4691, -126.83648, 15.809981, -116.236
4692, -136.8605, 10.503563, -131.90311
4693, 14.216039, 7.3069613, 192.23195
4694, 9.5544019, 14.836652, 189.98702
4695, 6.2610631, 7.2724633, 189.38868
4696, -10.893053, 41.617133, 172.04233
4697, -13.307606, 30.529908, 180.15282
4698, -11.750056, 41.096164, 181.19573
4699, -3.6562874, 30.929819, 171.73795
4700, -2.0987375, 41.496075, 172.78086
4701, -4.5132902, 30.408849, 180.89135
4702, 1069.0196, 45.389611, -17.885079
4703, 785.41861, 30, 78.530431
4704, 393.18199, 30, -16.366289
4705, 15.363647, 171.65878, -120.43862
4706, 50.34769, 185.3237, -107.69945
4707, 18.282058, 199.20101, -120.50695
4708, -34.162829, 273.50244, -115.59062
4709, -86.31652, 265.54613, -82.431915
4710, -64.529857, 240.29805, -104.16934
4711, -12.322709, 153.80932, -121.90907
4712, -9.4042987, 181.35155, -121.97741
4713, -122.28493, 10.210557, -166.76962
4714, -123.4223, 10.479532, -155.9342
4715, -39.87131, 222.1228, -110.82664
4716, -67.398476, 211.10068, -102.17508
4717, -88.358902, 30.731476, -177.89958
4718, -84.275148, 44.608369, -176.04945
4719, -104.05614, 46.123108, -168.15015
4720, 716.00723, 30, -136.50885
4721, 769.28889, 30, -130.96747
4722, 736.31692, 30, -85.274206
4723, 700.25246, 30, -74.875366
4724, 76.315674, 77.124044, 95.027817
4725, -123.1208, 37.613697, -156.42953
4726, -121.59951, 26.602639, -158.70633
4727, 424.55109, 30, -44.184669
4728, -171.64188, 26.09946, 16.42813
4729, -161.64823, 16.319236, 15.579054
4730, -175.50786, 18.637446, 5.5121783
4731, -165.51421, 8.8572212, 4.6631028
4732, -173.75373, 9.7802244, 13.755174
4733, -5.9753917, 24.792846, 144.05721
4734, 1.1497449, 23.213181, 157.99554
4735, -10.118721, 31.984078, 160.41594
4736, -5.7558575, 219.50235, -122.51604
4737, -6.0796944, 243.09587, -122.49757
4738, 30.87382, 248.67895, -116.14481
4739, -185.75508, 33.701553, -203.9276
4740, -194.95581, 33.928005, -198.41631
4741, -173.32731, 19.175359, -214.74955
4742, -177.25894, 9.5095505, -213.65113
4743, -3.7023315, 43.81729, 139.64097
4744, -16.722647, 40.975556, 152.78818
4745, 46.727962, 196.66406, 110.97389
4746, -121.49675, 158.4689, -3.5223618
4747, -13.476109, 30.369286, -191.24815
4748, -23.867501, 29.908252, -195.18264
4749, -271.52961, 12.857775, -16.8016
4750, -266.99816, 12.857775, -29.781696
4751, -260.59209, 12.857775, -20.615632
4752, -211.17844, 34.883511, 39.021162
4753, -212.8785, 28.443122, 48.756124
4754, -203.3895, 28.70491, 49.911097
4755, -207.16725, 18.012421, 46.276431
4756, -66.4255, 45.458048, -153.34931
4757, -49.460466, 45.458048, -140.98999
4758, -89.280344, 30, 265.21871
4759, -208.66009, 12.204424, 70.14624
4760, -275.73394, 9.3148238, -4.4889519
4761, -97.535284, 164.71509, 73.976258
4762, -107.78944, 161.28707, 54.67089
4763, -107.83407, 129.08104, 54.577503
4764, -200.45903, 9.5690683, -157.35435
4765, -201.26007, 19.521316, -150.26857
4766, -151.74931, 50.271683, -124.9561
4767, -157.48451, 50.523139, -114.57109
4768, -166.20231, 40.794822, -120.98511
4769, -172.31916, 50.523139, -122.05205
4770, 37.123472, 35.351339, -233.6738
4771, 45.358495, 40.824267, -224.74894
4772, 36.578826, 42.894889, -231.28755
4773, 1218.1518, 30, 121.57826
4774, 1198.8891, 30, 98.131287
4775, 50.07614, 49.955764, -160.05664
4776, 76.132344, 49.955764, -174.39801
4777, -180.61177, 9.7802244, 7.2042637
4778, -199.77669, 9.851561, 192.54681
4779, 86.002143, 331.2978, -85.05053
4780, 119.74261, 226.55024, -24.124388
4781, 119.63305, 188.04746, -12.470535
4782, 76.33386, 203.65793, 93.174434
4783, 63.616364, 170.46553, 104.69836
4784, -22.279614, 15.097693, -140.10585
4785, -47.232511, 39.207659, -114.09475
4786, -21.664969, 23.749611, -108.53609
4787, 32.789262, 24.190762, -245.02687
4788, 35.663368, 24.36482, -236.5015
4789, 35.017586, 16.781849, -239.75976
4790, -152.45418, 36.33312, -106.0588
4791, -147.37944, 45.809981, -99.533171
4792, -146.24936, 29.132507, -91.156867
4793, -166.86277, 50.523139, -104.07447
4794, -165.7327, 33.845666, -95.698166
4795, -160.65796, 43.322527, -89.172536
4796, 23.923454, 171.15838, 120.30129
4797, -105.87176, 36.948638, -138.84351
4798, -94.600185, 45.458048, -136.22379
4799, -89.907233, 45.458048, -119.72688
4800, -122.13717, 51.490589, -123.74216
4801, -176.89948, 16.897933, -4.6069206
4802, -185.139, 17.820937, 4.4851501
4803, -182.0034, 8.0407122, -2.9148352
4804, 37.705396, 35.015204, 233.08082
4805, 36.506255, 42.243493, 226.04407
4806, 37.333367, 42.445408, 236.33229
4807, 44.953779, 39.484197, 229.49492
4808, -272.75825, 15.698994, -51.152986
4809, -281.27033, 15.698994, -36.395885
4810, 53.925802, 14.980749, 279.58088
4811, 43.617039, 14.980749, 263.35852
4812, -116.69336, 240.77568, 11.569562
4813, -117.02476, 225.82658, -29.688506
4814, 109.87417, 14.597603, -264.19591
4815, 116.59593, 14.597603, -234.27486
4816, 88.331492, 14.597603, -244.80887
4817, 41.580085, 20.245938, -190.11198
4818, 28.996592, 25.597856, -196.83889
4819, -29.253526, 23.347734, 257.07957
4820, 27.451004, 52.668739, 260.25323
4821, 99.435364, 14.597603, -225.14308
4822, 92.062399, 281.9798, 79.910908
4823, 22.387586, 39.559171, -261.83703
4824, 29.212156, 39.810312, -254.61894
4825, 27.59077, 32.296641, -257.22688
4826, 116.29096, 89.584511, -37.913415
4827, 110.08894, 122.14699, -51.93422
4828, 102.12902, 34.231785, -229.06597
4829, 131.12515, 44.597603, -228.52161
4830, 32.675228, 8.5344503, 211.86473
4831, 40.723686, 7.2671175, 225.00056
4832, 45.733033, 8.5344503, 219.01289
4833, 33.362467, 15.801568, 214.79688
4834, -245.28533, 45.398317, 64.829397
4835, -182.70088, 28.271141, 2.8534791
4836, 1055.2328, 14.882206, 29.393569
4837, 51.008891, 10.407661, 227.61452
4838, 895.61164, 30, 125.41932
4839, 41.343152, 52.640482, -226.11775
4840, 36.33295, 50.254406, -237.5662
4841, 678.16828, 30, 103.11338
4842, 663.55381, 30, 139.71268
4843, 38.982523, 25.229894, -225.25731
4844, 46.203889, 30.387367, -231.36001
4845, 181.02195, 30, -147.05736
4846, -23.606208, 33.199503, -260.22367
4847, -37.066947, 44.25513, -267.43693
4848, -39.677989, 28.976082, -264.11605
4849, -191.51108, 7.2096626, 10.396682
4850, -193.88278, 9.7802244, 16.107381
4851, -196.2427, 17.275828, 18.326347
4852, -191.24979, 16.989887, 10.379294
4853, -235.60403, 46.666687, -139.52199
4854, -232.33993, 30, -151.33867
4855, 1272.1944, 15.751461, 29.712106
4856, 13.672821, 38.494322, -195.71157
4857, 12.626135, 26.13492, -189.82373
4858, -206.52795, 45.57101, 107.70333
4859, -191.93458, 45.57101, 90.782217
4860, -174.40896, 13.521789, 226.18366
4861, -165.55397, 13.521789, 202.27103
4862, 89.713001, 30.029924, -234.56276
4863, 30.064853, 44.980749, 282.8326
4864, 22.044704, 45.53594, 263.77284
4865, -65.344528, 30, 274.46037
4866, 4.7787807, 42.665781, -263.17239
4867, 20.317192, 32.117622, -262.83408
4868, -144.89021, 30.404439, 104.93333
4869, -223.44615, 30, 174.9603
4870, -201.08814, 49.636292, 164.49014
4871, -213.09562, 19.636292, 174.11714
4872, -232.86404, 30, 161.01014
4873, -28.206306, 44.15026, -199.96501
4874, -28.500657, 37.137488, -200.33411
4875, 772.36108, 30, -20.779565
4876, 753.10757, 30, -55.508478
4877, -119.99437, 46.123108, -167.19019
4878, -261.23456, 43.89049, 43.367442
4879, -251.5333, 49.743013, 38.593493
4880, -256.46132, 33.633503, 43.964512
4881, -258.67247, 36.481898, 30.787629
4882, 101.38208, 30, 101.26154
4883, 70.7791, 30, 118.13643
4884, 96.795805, 46.273815, 129.07173
4885, 96.654309, 16.273815, 121.05868
4886, -214.50053, 8.8753163, 55.089542
4887, -210.65175, 8.8753163, 43.320951
4888, -205.01152, 9.1371046, 56.244516
4889, -263.34801, 30, 99.104252
4890, -232.4585, 17.640598, 36.403384
4891, -233.82256, 26.858863, 42.840609
4892, -228.51343, 18.203678, 44.358245
4893, -31.183232, 9.3151381, 249.35761
4894, -26.951548, 8.5390733, 257.32328
4895, -35.938677, 14.808661, 264.90625
4896, 755.66291, 30, 93.414708
4897, 739.20372, 30, 64.793296
4898, -6.0633162, 35.538484, -285.93872
4899, -17.273075, 29.313238, -285.37379
4900, 68.77089, 30.619683, -239.11612
4901, 57.6227, 35.686728, -231.30366
4902, 57.352078, 25.320322, -239.17246
4903, -15.975131, 10.975556, 162.96318
4904, -33.584159, 44.969919, 153.74277
4905, -26.95205, 43.262636, 137.85014
4906, 37.832785, 17.728454, -220.21998
4907, 36.8155, 7.5954931, -221.67651
4908, 47.045655, 10.132961, -224.40006
4909, 43.396372, 10.132961, -216.39369
4910, -201.14944, 11.574137, -126.7363
4911, -210.58623, 11.574137, -109.51532
4912, -12.396449, 39.42475, -260.7886
4913, -16.893975, 28.800829, -264.1892
4914, 993.22937, 30, 67.286171
4915, 1017.6251, 30, 63.219866
4916, 88.932056, 15.187361, -268.74926
4917, 87.583328, 29.784964, -250.84805
4918, -189.72814, 21.30325, -130.74261
4919, -203.75105, 26.3958, -134.56512
4920, 52.712188, 49.843056, 230.78796
4921, 51.885077, 49.641141, 220.49973
4922, 59.563829, 34.576961, 228.01064
4923, -224.79516, 30, -168.79787
4924, -139.04173, 30, -223.97128
4925, -155.95225, 30, -214.08893
4926, -142.25807, 30, -209.22218
4927, -37.772298, 23.50091, -212.07158
4928, -40.320404, 30.436774, -215.26679
4929, -142.17737, 15.197355, 108.02785
4930, -163.37492, 15.207084, 107.92125
4931, 3.8826003, 49.899542, -164.82525
4932, 44.9953, 10.006214, -193.46823
4933, 37.796389, 36.908787, -165.96038
4934, 43.577713, 40.935455, -182.6639
4935, 32.776634, 46.953022, -161.70924
4936, 38.557959, 50.979691, -178.41276
4937, 48.834432, 32.561127, -262.61666
4938, 37.686242, 37.628172, -254.8042
4939, 42.884734, 29.522294, -242.6042
4940, 1283.2184, 30, 46.330238
4941, 1295.1926, 30, 15.413051
4942, -133.19218, 30, -249.12002
4943, -160.96421, 9.5095505, -202.16629
4944, -38.394261, 14.25513, -283.24618
4945, -20.713577, 14.25513, -285.44699
4946, 21.841325, 9.5608389, 183.29419
4947, 11.716344, 18.910768, 180.80437
4948, 43.486319, 26.276775, -107.65857
4949, 37.826313, 56.276775, -116.30687
4950, 34.369485, 9.2678874, -242.59927
4951, 37.319456, 7.5139617, -229.97211
4952, 43.726501, 9.2678874, -235.64424
4953, -162.0766, 13.322527, -84.332801
4954, -168.71085, 13.322527, -70.432805
4955, -175.1256, 28.652837, -77.69313
4956, 44.041441, 28.517455, 242.84069
4957, -266.25618, 16.563037, 4.9310331
4958, -113.40105, 23.260376, -35.641767
4959, -113.53063, 53.260376, -44.86993
4960, 60.41757, 25.438536, -210.76236
4961, 71.752562, 32.421233, -209.10146
4962, 61.269569, 26.995125, -197.03299
4963, -217.70816, 9.7680279, -36.583712
4964, 23.166379, 25.969625, -191.68977
4965, 33.894756, 43.403489, -208.83402
4966, 39.561027, 41.549551, -198.42355
4967, 1026.1729, 30, -78.421415
4968, 1005.7659, 30, -93.439846
4969, -110.01395, 326.66285, -51.568123
4970, -121.8453, 323.75766, 3.7476391
4971, -114.23271, 290.42051, -19.607074
4972, 38.946592, 50.979691, -190.39691
4973, 35.171277, 35.02753, 241.94683
4974, 3.7068082, 28.832065, 180.71602
4975, 3.1024163, 35.324205, 190.94157
4976, 41.342239, 30.985905, -192.9098
4977, 38.638326, 17.674779, 223.3985
4978, -258.93088, 23.146003, -22.69171
4979, -260.92025, 30, -58.76109
4980, -283.35286, 30, -56.437749
4981, -210.81582, 21.07974, 60.178156
4982, -234.43654, 9.3283621, 45.126837
4983, -222.57937, 8.8753163, 45.890051
4984, -226.52443, 8.3122356, 37.93519
4985, -185.19414, 44.862441, 206.74424
4986, -198.87674, 49.709328, 195.23887
4987, 23.674248, 52.185405, -257.55471
4988, 30.498818, 52.436546, -250.33662
4989, -4.0979276, 42.36165, -264.87521
4990, 46.659112, 50.56986, -210.58909
4991, 45.612761, 19.08206, 235.95534
4992, 38.834353, 10.407661, 229.7551
4993, 38.29219, 18.092224, 232.13048
4994, 53.981859, 33.676436, 211.63472
4995, 43.232458, 49.843056, 233.1023
4996, 42.405347, 49.641141, 222.81407
4997, 41.581327, 115.51604, 113.52463
4998, -185.61068, 31.449809, -125.01665
4999, -182.34213, 21.724199, -122.8327
5000, -188.86288, 13.521789, 213.38428
5001, -157.81489, 30, -231.99565
5002, 15.447399, 52.764421, -196.56616
5003, 32.906823, 74.842985, -118.0782
5004, 40.564854, 105.19204, -114.94613
5005, -26.975701, 23.511843, -255.50928
5006, -33.556972, 9.2567125, -250.01396
5007, -40.044209, 23.977664, -248.25257
5008, 195.04812, 30, -216.83091
5009, -285.1752, 37.472354, -20.745817
5010, -283.35633, 12.857775, -24.607263
5011, -32.594982, 42.328413, 191.30986
5012, -26.055295, 48.75123, 201.18047
5013, -43.639882, 46.221116, 196.33282
5014, -1.3802743, 50.480376, -264.87521
5015, -164.04487, 9.8169579, 121.73542
5016, -194.99861, 48.829341, -24.653593
5017, -192.70965, 37.320258, -12.990976
5018, 15.621714, 12.237625, 169.40591
5019, 98.805972, 224.9918, -58.452567
5020, 105.02059, 192.49344, -53.856074
5021, -191.92496, 48.490917, -11.36154
5022, -91.077741, 55.899376, 79.212634
5023, -99.677556, 86.800808, 70.578365
5024, -82.880269, 76.583647, 89.387756
5025, -247.14887, 42.458217, 30.509575
5026, -249.68872, 34.857557, 27.740683
5027, -147.21035, 50.250877, 193.83239
5028, -132.62578, 44.532479, 200.78111
5029, -136.08987, 51.57172, 188.03913
5030, -145.66359, 34.783357, 197.97565
5031, -134.54311, 36.104199, 192.18239
5032, -245.27237, 30, 142.47844
5033, -250.15009, 30, 124.46981
5034, -231.37735, 30, 125.85677
5035, -206.47227, 33.6645, 182.26898
5036, -191.24979, 23.879191, 6.1796249
5037, -173.28225, 11.822603, -21.437965
5038, -185.8656, 11.822603, -22.248673
5039, 117.97089, 160.62808, -33.282207
5040, 15.601945, 10.40502, -181.9426
5041, 45.250779, 93.19329, 112.50544
5042, 15.302101, 93.253978, 119.63836
5043, 791.71973, 30, -29.780431
5044, 792.88745, 30, -6.4234488
5045, -86.616898, 30, -205.30471
5046, -73.520577, 14.608369, -197.35818
5047, -255.26804, 22.223134, 36.5452
5048, -283.89363, 46.738885, 29.607982
5049, -15.779976, 20.370197, 111.65241
5050, -243.56533, 29.071375, 41.392797
5051, -237.70205, 24.726679, 54.076499
5052, -240.28694, 36.085842, 33.9318
5053, -237.09221, 25.671191, 36.134034
5054, -230.54417, 33.873329, 35.379611
5055, -245.56678, 28.075657, 31.771251
5056, -242.37205, 17.661006, 33.973485
5057, -25.190814, 44.808661, 267.73342
5058, -39.387368, 9.2567125, -230.88182
5059, -41.377578, 23.564746, -228.72744
5060, -127.88062, 10.479532, -139.18343
5061, -86.807109, 45.458048, -150.56412
5062, -71.109869, 30.066417, -160.31355
5063, -90.890863, 31.581156, -152.41426
5064, -9.8281193, 278.92071, -122.22944
5065, 350.22432, 30, -49.898965
5066, -220.67136, 45.57101, 120.99756
5067, -37.21269, 142.39712, -113.16714
5068, -14.601762, 125.99316, -121.54889
5069, 1025.6037, 30, 127.51516
5070, 1008.2813, 30, 89.706113
5071, 82.867446, 183.48721, -90.334014
5072, 58.968762, 22.447574, -180.35219
5073, 50.634939, 10.239724, -177.7056
5074, 68.023616, 12.44136, -167.94581
5075, 50.614271, 22.681084, -171.77028
5076, -8.1138613, 51.944757, 190.04324
5077, -11.961685, 42.553368, 189.6047
5078, -7.9022324, 50.487553, 181.63427
5079, 46.045937, 12.44136, -160.0632
5080, 79.174118, 12.44136, -183.00098
5081, -10.067718, 111.19903, 122.01381
5082, 28.657261, 10.239724, -169.82299
5083, -184.92568, 30.445231, 12.837557
5084, -193.91252, 35.465839, 11.955702
5085, -186.59897, 28.291781, 24.494908
5086, -192.73422, 24.581057, 13.722393
5087, 49.655735, 44.980749, 280.32661
5088, -239.93202, 43.97896, 34.012807
5089, -230.18925, 41.766448, 35.460618
5090, -179.39851, 9.7802244, 25.790613
5091, -167.29301, 16.319236, 27.614494
5092, -188.11418, 7.2096626, 2.9793082
5093, -192.42809, 34.763973, 4.4129333
5094, -183.87918, 39.155924, 1.0867874
5095, 10.171881, 278.92071, -122.22944
5096, 15.286406, 52.185405, -263.61698
5097, 76.356947, 30, -119.88283
5098, -37.264969, 49.624977, -226.42901
5099, 615.03668, 30, 146.67072
5100, 583.21252, 30, 154.96323
5101, 64.047622, 14.93582, 233.01558
5102, 89.418902, 45.516866, 204.49442
5103, -207.98037, 49.567806, 48.680522
5104, 62.551466, 163.54492, -103.70065
5105, 27.567423, 149.88, -116.43981
5106, 100.51512, 46.273815, 161.02681
5107, 74.049434, 46.273815, 165.98506
5108, 1279.7459, 30, -89.78472
5109, 1234.0972, 30, -69.203865
5110, 1240.7653, 44.506122, -65.178953
5111, 1276.1332, 14.506122, -71.078815
5112, 1092.6051, 30, 68.293745
5113, 43.274345, 8.6743985, 252.89567
5114, -105.3359, 30, -61.65278
5115, -133.53263, 45.809981, -84.136276
5116, -104.77412, 15.809981, -79.034006
5117, -133.40304, 15.809981, -74.908113
5118, -184.00867, 9.7802244, 14.621637
5119, -5.0818203, 34.671062, 190.47139
5120, 4.8733133, 16.953022, -155.5593
5121, -19.77004, 31.584167, 168.83081
5122, -70.665961, 38.540448, -101.4373
5123, -56.675248, 15.458048, -110.70053
5124, 140.64707, 14.597603, -257.05604
5125, 163.24678, 30, -239.28295
5126, 1.0022274, 10.649999, -187.34014
5127, -4.6727946, 10.434136, -178.24642
5128, -7.1272649, 10.649999, -191.70895
5129, -121.95788, 30, -217.24227
5130, -29.842501, 26.101842, -200.57912
5131, -44.935332, 24.281135, -203.12141
5132, -33.115584, 30.98185, -188.18873
5133, -43.593487, 35.316781, -202.8764
5134, 52.601083, 128.72088, -110.80979
5135, -216.82281, 44.028209, 183.11213
5136, -225.84487, 24.273633, 54.839713
5137, 56.302408, 13.153633, 185.63663
5138, 103.64577, 91.65331, -64.688872
5139, -40.890664, 32.35955, -177.44627
5140, 7.3629283, 144.76764, -121.88752
5141, 32.396589, 123.60851, -116.25749
5142, -21.546151, 10.434136, -176.54351
5143, -27.828953, 101.74177, -118.42061
5144, -8.151033, 99.181147, -122.17358
5145, -17.341297, 79.968797, -121.06491
5146, -167.71303, 27.495003, -22.4808
5147, -12.557636, 10.434136, -168.98233
5148, -225.22998, 46.666687, -120.33117
5149, -21.438973, 53.690912, 264.28557
5150, -24.550576, 38.499573, 259.94751
5151, -11.500735, 53.690912, 263.01838
5152, -207.123, 46.666687, -120.71993
5153, 45.757718, 50.56986, -201.69474
5154, 39.300222, 50.56986, -206.84172
5155, 32.489096, 50.979691, -195.54389
5156, -183.87353, 50.523139, -116.64891
5157, -64.355736, 11.350802, -171.23255
5158, -76.172857, 15.458048, -155.17226
5159, -73.640896, 14.608369, -180.65758
5160, 106.46869, 264.15629, -50.913533
5161, 121.65541, 264.05622, 0.13377928
5162, -38.984011, 13.262636, 107.19811
5163, -48.924377, 39.162012, 101.27671
5164, -27.139117, 33.632833, 110.73243
5165, -117.81001, 120.15317, 27.324436
5166, -23.424983, 30.926576, 260.48956
5167, -10.375141, 46.117914, 263.56044
5168, -213.7725, 42.2244, 40.104877
5169, -203.9474, 41.168151, 31.102265
5170, -222.85939, 40.187095, 34.952575
5171, -146.68155, 13.322527, -64.547478
5172, -144.96523, 13.322527, -87.779988
5173, -121.43762, 15.6724, -10.094589
5174, -120.25135, 38.932776, -19.078157
5175, 108.9908, 56.059819, 49.276028
5176, 325.46532, 30, -91.930689
5177, -221.4213, 49.567806, 49.576938
5178, -226.09306, 52.656594, 37.291025
5179, -212.65213, 52.656594, 36.394609
5180, -222.06711, 34.966123, 58.474378
5181, 71.725623, 13.153633, 176.46435
5182, 74.771796, 14.035295, 193.81808
5183, -250.59803, 29.288807, 56.648214
5184, -253.26659, 23.218852, 46.166746
5185, -217.68562, 8.8753163, 36.501106
5186, -152.30307, 49.799537, 122.78685
5187, -133.21797, 30, 241.6067
5188, -35.857219, 25.945475, 158.15902
5189, -212.24708, 9.851561, 178.38307
5190, -222.18703, 30, 142.27335
5191, -30.414404, 237.6776, -115.85874
5192, 25.708235, 7.3069613, 197.90483
5193, -117.33683, 258.71751, -13.655962
5194, -105.2542, 257.00355, -61.430712
5195, -25.239215, 51.008748, -196.24441
5196, -7.2616424, 24.167468, -285.31026
5197, -10.702144, 9.1093603, -285.38346
5198, -16.598048, 23.36449, -271.30923
5199, -212.69714, 16.37092, 33.584952
5200, -34.783001, 46.12874, -206.82744
5201, -38.056084, 51.008748, -194.43705
5202, -140.19012, 49.542988, -193.53876
5203, 535.82868, 30, 161.39974
5204, -97.171974, 15.458048, -132.89137
5205, -129.40191, 21.490589, -136.90664
5206, -113.43738, 30, -117.79002
5207, -177.57928, 20.679825, -16.684994
5208, -153.10505, 15.6724, -14.128669
5209, -212.90354, 30, -147.83833
5210, -199.63359, 36.542359, -128.83915
5211, -35.055186, 46.12874, -218.01828
5212, -42.530188, 33.933011, -223.67753
5213, -190.20329, 40.417851, -4.5396902
5214, -196.09619, 11.822603, -23.995153
5215, 28.427831, 15.841412, 206.62398
5216, 26.109133, 16.8678, 195.50099
5217, -198.15528, 48.511557, 39.67791
5218, -40.61761, 42.328413, 180.33816
5219, 441.29019, 30, 84.242866
5220, -36.631552, 35.57853, 169.78541
5221, 1.9386955, 9.9212967, 179.9368
5222, 7.6121785, 22.158922, 169.31755
5223, 44.743785, 19.400848, -234.18771
5224, 90.722144, 30, 267.95496
5225, 114.41765, 30, 259.02856
5226, 100.95767, 14.93582, 235.30818
5227, -107.50875, 220.05822, -58.043222
5228, 1098.0469, 30, -128.4279
5229, 40.70194, 269.75824, -115.19249
5230, 1299.3548, 30, -72.333015
5231, 796.50634, 30, 127.52512
5232, 812.75545, 30, 100.90732
5233, 7.1752054, 13.81729, 141.50373
5234, -5.8451102, 10.975556, 154.65094
5235, 14.300342, 12.237625, 155.44206
5236, 871.45606, 30, 101.69507
5237, 845.26888, 30, 96.151638
5238, 33.428825, 42.511795, 244.13179
5239, 5.0838758, 116.95148, -121.52734
5240, 9.1456954, 45.53594, 265.05804
5241, 129.22544, 30, 113.79804
5242, 132.94476, 30, 145.75311
5243, 124.49767, 16.273815, 133.59518
5244, -137.81059, 14.532479, 195.19406
5245, -133.02198, 24.982245, 189.90583
5246, -21.061607, 14.808661, 269.85766
5247, -24.874766, 14.808661, 282.05668
5248, -10.059093, 16.117914, 277.8837
5249, -13.697533, 46.117914, 277.77586
5250, -3.8893981, 34.187487, 112.52325
5251, -4.845654, 13.81729, 130.03916
5252, 43.81556, 30.195488, -179.86607
5253, 61.204236, 32.397124, -170.10628
5254, 35.870751, 42.690953, -239.59123
5255, -135.53627, 37.30057, -122.18814
5256, -18.144158, 50.608611, 191.78824
5257, -195.87232, 49.709328, 174.59419
5258, 13.431313, 18.429124, -190.21149
5259, -72.354546, 30, -275.77558
5260, -77.571449, 30, -255.21391
5261, 404.27518, 30, 171.87324
5262, -212.58393, 15.57101, 125.83793
5263, 70.303755, 29.430271, -178.69129
5264, 52.170051, 29.961978, -188.44798
5265, -16.746554, 15.097693, -156.95035
5266, -93.42189, 16.123108, -172.75829
5267, -87.921583, 30, -266.91697
5268, 84.21395, 30.452686, 216.79359
5269, 96.813671, 44.93582, 233.39299
5270, 1255.3429, 30, -109.13026
5271, -172.24698, 30, -225.57377
5272, 1181.081, 30, -105.04686
5273, -111.6694, 323.75766, 35.944356
5274, -29.291741, 248.01251, 118.41524
5275, -117.00543, 273.66662, 27.602106
5276, 434.81898, 30, -73.790959
5277, 392.80976, 30, -66.073905
5278, 1097.0004, 30, -76.169239
5279, 1202.1606, 30, -104.46479
5280, 414.66546, 30, -104.06609
5281, 464.0082, 30, -111.30056
5282, -30.682967, 21.373507, 201.82212
5283, 195.76592, 30, 51.417002
5284, -123.28888, 50.47801, 166.96462
5285, -90.645796, 166.79173, -78.223863
5286, -78.790064, 184.55062, -93.079145
5287, -91.439693, 199.40342, -77.050165
5288, 34.249365, 35.177281, -242.19917
5289, 368.05076, 30, -108.10563
5290, -267.10548, 9.3148238, 0.17990378
5291, -45.313473, 53.749611, -112.77003
5292, -68.746924, 53.082399, -100.11257
5293, -71.722792, 45.458048, -133.50351
5294, 38.33674, 17.646923, -228.51557
5295, -198.42107, 48.511557, 27.680131
5296, -44.079774, 225.90293, 114.16054
5297, -67.043477, 207.33597, 101.54633
5298, -75.800882, 246.33399, 93.356844
5299, -84.905822, 14.608369, -189.7567
5300, 37.879443, 52.640482, -217.1277
5301, -17.86597, 10.975556, 143.18637
5302, -0.29103909, 46.117914, 265.45651
5303, -195.18215, 45.330311, -64.160638
5304, -180.33615, 45.330311, -68.756056
5305, -258.48607, 12.857775, -44.538797
5306, -244.31193, 20.142374, -45.662785
5307, -120.25462, 36.399038, 173.99801
5308, 113.7673, 284.15883, 32.483837
5309, 65.744359, 53.856006, 99.973095
5310, 54.22184, 77.124044, 109.31851
5311, 72.543144, 45.187361, -272.55178
5312, -238.3268, 9.3283621, 35.852247
5313, -37.015699, 50.370197, 115.66876
5314, 227.20673, 30, -118.19447
5315, -60.376615, 15.912383, 104.61841
5316, 698.80369, 30, 77.571272
5317, 13.38023, 16.953022, -124.49249
5318, -166.40877, 28.002365, 231.48514
5319, 1321.8157, 30, 2.7345896
5320, 833.46112, 30, -89.62697
5321, 90.169043, 246.13079, 82.306953
5322, 503.83136, 30, 153.05622
5323, -3.8343945, 52.889263, 264.02605
5324, -174.95926, 24.896664, -95.946676
5325, 21.191898, 52.764421, -189.17258
5326, 24.781339, 52.833629, -198.35908
5327, 17.827918, 45.59805, -198.76017
5328, 26.822825, 52.833629, -205.95436
5329, 30.44761, 50.979691, -187.9486
5330, -96.246473, 16.123108, -153.72425
5331, -114.42101, 16.123108, -150.4774
5332, -28.095373, 13.262636, 128.24833
5333, -176.25568, 45.330311, -86.069434
5334, -247.78875, 9.3283621, 42.406005
5335, 1099.8102, 30, 86.233941
5336, -109.96269, 16.123108, -167.22816
5337, -223.68914, 15.398317, 64.807797
5338, 1257.5969, 15.751461, 52.256727
5339, -108.5701, 30, 254.40949
5340, 1252.3907, 30, 57.894352
5341, -248.34397, 30, -63.32241
5342, -111.84922, 46.123108, -153.80982
5343, -18.582569, 142.59644, 120.535
5344, -126.66846, 14.532479, 197.11088
5345, -106.80247, 14.115456, 198.28579
5346, -119.59143, 14.532479, 217.29085
5347, 1081.1044, 14.258154, 56.058175
5348, 1072.1554, 14.258154, 29.982894
5349, 87.22007, 26.059819, 77.129049
5350, 743.54917, 30, 26.607778
5351, 703.14913, 30, 39.385754
5352, -176.4019, 20.514039, -110.06063
5353, -160.97052, 22.262429, -94.910184
5354, 33.560798, 14.980749, 282.75822
5355, 30.697044, 14.980749, 268.28387
5356, -79.700019, 163.04197, 90.862552
5357, -62.075334, 178.80857, 105.10217
5358, -204.52418, 36.188004, -138.45189
5359, 15.333281, 52.464907, 191.75776
5360, 87.361565, 56.059819, 85.142106
5361, -50.175824, 35.617117, -186.8713
5362, -63.893539, 44.608369, -178.83464
5363, -54.608379, 41.350802, -169.4096
5364, 712.53634, 30, -43.907805
5365, -242.56399, 9.3283621, 59.96976
5366, -231.76798, 15.398317, 55.608305
5367, 1035.2887, 14.882206, 37.65573
5368, -7.0452297, 51.008522, 172.48087
5369, -39.636874, 9.2567125, -240.92279
5370, -53.672531, 14.308033, -230.00443
5371, -260.84987, 43.89049, 56.919644
5372, 294.44627, 30, -110.36686
5373, -131.68671, 15.809981, -98.140623
5374, -174.30631, 49.401811, -195.54552
5375, 1216.1349, 30, 76.782106
5376, 29.876028, 7.5936729, 256.44436
5377, 22.00591, 50.979691, -183.11169
5378, -172.82018, 36.984242, 14.661438
5379, 113.7937, 30, -100.56579
5380, 0.35454044, 79.968797, -121.91934
5381, -206.16571, 49.401811, -186.64304
5382, -197.36478, 49.875671, -146.11867
5383, -188.32013, 49.875671, -130.81695
5384, 1019.4029, 30, 31.368892
5385, 150.85467, 30, 77.931957
5386, 123.01132, 30, 65.395458
5387, -48.654909, 94.988746, -111.34682
5388, -50.439881, 118.14573, -110.03887
5389, 709.32112, 30, 5.7319123
5390, 76.782426, 30, 94.656026
5391, 2.0040221, 50.370197, 121.00734
5392, 0.61732345, 9.9212967, 165.97295
5393, 749.89235, 30, -5.8687611
5394, -182.45019, 28.38423, 219.20279
5395, 47.352211, 30.250717, 232.8978
5396, -212.61542, 46.198231, -75.32873
5397, -206.28316, 31.528542, -67.241792
5398, 1233.9744, 30, 69.800022
5399, -257.37453, 10.288229, -27.507373
5400, -167.17534, 29.463041, -109.81212
5401, -140.5666, 51.490589, -130.70043
5402, -138.00117, 45.809981, -110.02979
5403, -177.9001, 43.521789, 223.33128
5404, -28.654805, 112.86218, 118.09999
5405, -60.429578, 73.21577, -106.50464
5406, -38.167253, 73.21577, -113.99112
5407, -9.5126973, 9.9212967, 174.28519
5408, -176.38412, 40.39881, -124.76814
5409, -187.16378, 9.7291129, -132.59119
5410, -179.77777, 10.150062, -124.68128
5411, 38.972904, 50.254406, -250.52189
5412, -146.81114, 43.322527, -73.775641
5413, 973.30829, 30, 88.852308
5414, -147.692, 24.749882, -105.27082
5415, -223.18579, 46.198231, -64.309596
5416, -161.44014, 29.211585, -120.19713
5417, -146.71898, 36.081664, -116.44381
5418, 978.80089, 30, 129.55569
5419, -29.225111, 24.238192, 142.26639
5420, -162.23821, 28.354479, -64.257653
5421, 80.622926, 15.432322, -213.41115
5422, 30.520553, 52.640482, -213.38033
5423, 297.56713, 30, -189.19753
5424, 32.226003, 52.668739, 247.41284
5425, -167.44876, 45.031952, -55.32058
5426, -231.02461, 36.340605, -43.553782
5427, -266.38001, 30, 79.311836
5428, -251.14862, 49.743013, 52.145695
5429, -41.921375, 13.262636, 143.85962
5430, -31.513969, 196.10116, 117.26195
5431, 47.698122, 8.6743985, 237.5574
5432, 36.130545, 52.602352, 239.61334
5433, -101.14262, 96.225685, -68.874659
5434, 366.23981, 30, 132.26287
5435, -218.18763, 37.098306, 47.238488
5436, 13.252141, 98.535007, -120.21598
5437, -212.48605, 16.666687, -97.622135
5438, -86.459817, 114.40081, -85.051634
5439, -90.927021, 138.85942, -78.065151
5440, -216.16764, 46.666687, -136.02165
5441, -220.58881, 49.79238, -36.661863
5442, -101.0247, 30, -217.01448
5443, 32.032069, 37.649488, 257.65218
5444, 79.932233, 45.187361, -246.40831
5445, -156.09962, 25.116447, 120.37753
5446, -160.86006, 43.521789, 213.8859
5447, 7.7255222, 10.40502, -188.2751
5448, 5.3798961, 35.629443, -191.31969
5449, 122.19338, 96.146692, 6.5470425
5450, -5.1034326, 9.9212967, 189.30032
5451, 111.49107, 331.2978, -47.397276
5452, 114.19494, 289.84736, -20.922177
5453, -107.1367, 54.772986, 56.721718
5454, -184.67475, 44.526194, -214.75182
5455, -17.496979, 50.608611, 164.41456
5456, -261.51806, 45.398317, 73.418575
5457, -14.636653, 50.370197, 121.25422
5458, 399.91422, 30, 78.128098
5459, 51.491711, 50.053576, 210.84467
5460, -164.73843, 43.322527, -71.859158
5461, -173.11557, 30.673201, -122.58419
5462, -168.3534, 19.089964, -121.79621
5463, -98.002143, 30, -197.70323
5464, -104.68682, 16.123108, -181.85741
5465, 1219.9284, 30, -116.98929
5466, -79.071289, 156.61832, -92.920433
5467, -59.251562, 146.05949, -106.82914
5468, -235.05665, 46.198231, -61.213408
5469, -228.76064, 46.198231, -53.978293
5470, -155.0395, 35.254146, 121.08587
5471, -83.467536, 231.75547, -83.168139
5472, -193.10009, 41.574137, -116.89742
5473, -171.52392, 15.031952, -40.827252
5474, -163.2035, 8.9399017, -120.39807
5475, -169.95685, 43.521789, 201.39525
5476, -0.8690282, 15.058108, -287.77416
5477, -220.83862, 46.198231, -52.368305
5478, -157.71602, 19.443465, -120.93793
5479, -16.204795, 27.079927, 129.11918
5480, -117.0112, 152.16242, 17.840585
5481, 122.29274, 318.54956, 6.0911983
5482, 105.03861, 29.090832, -70.281119
5483, -77.875511, 132.83118, -94.048035
5484, -70.600428, 115.04519, -99.982063
5485, -243.88828, 49.743013, 33.109817
5486, -207.17384, 9.7680279, -33.909336
5487, -191.95517, 49.401811, -201.13892
5488, 800.77993, 30, -127.25066
5489, -37.459804, 9.0450936, 225.94456
5490, -161.81141, 15.031952, -30.402455
*Element, type=C3D10, ELSET=PART1
1, 666, 677, 623, 662, 3499, 3501, 2805, 
2806, 3500, 2779
2, 830, 896, 887, 827, 3502, 3505, 3503, 
3497, 3504, 3506
3, 540, 920, 491, 499, 3507, 3510, 3508, 
2466, 3509, 3511
4, 386, 83, 435, 857, 1778, 1554, 1732, 
3512, 3513, 3514
5, 835, 302, 553, 301, 1750, 2230, 3515, 
1692, 1250, 2231
6, 782, 865, 920, 770, 3516, 3519, 3517, 
3318, 3518, 3520
7, 643, 325, 701, 640, 2723, 3522, 3521, 
2732, 2712, 3523
8, 394, 770, 140, 139, 3524, 3269, 1427, 
1428, 3268, 1088
9, 920, 540, 773, 499, 3507, 3526, 3525, 
3509, 2466, 3527
10, 693, 697, 667, 708, 3004, 3529, 3528, 
3003, 2979, 3530
11, 842, 323, 940, 853, 3531, 3535, 3533, 
3532, 3534, 3536
12, 920, 773, 540, 772, 3525, 3526, 3507, 
3537, 3279, 3538
13, 489, 579, 900, 496, 3539, 3542, 3541, 
3540, 2323, 3543
14, 193, 85, 491, 865, 2044, 2007, 2047, 
3544, 3545, 3546
15, 832, 836, 295, 868, 1862, 1864, 1863, 
3547, 3548, 3549
16, 931, 792, 844, 367, 3550, 3554, 3552, 
3551, 3553, 3555
17, 875, 869, 915, 878, 3556, 3560, 3558, 
3557, 3559, 3561
18, 772, 919, 540, 920, 3562, 3564, 3538, 
3537, 3563, 3507
19, 107, 369, 794, 106, 1373, 3565, 3362, 
1055, 1374, 3361
20, 866, 372, 868, 529, 3566, 3570, 3568, 
3567, 3569, 3571
21, 395, 228, 227, 547, 3572, 1176, 3574, 
3573, 2344, 2343
22, 562, 854, 852, 856, 3575, 3579, 3577, 
3576, 3578, 3580
23, 848, 858, 921, 545, 3581, 3585, 3583, 
3582, 3584, 3586
24, 935, 486, 838, 839, 3587, 3591, 3589, 
3588, 3590, 3592
25, 353, 508, 399, 50, 3593, 3595, 1523, 
1319, 3594, 1522
26, 600, 479, 346, 450, 3596, 1816, 3598, 
3597, 1828, 1695
27, 868, 296, 866, 548, 3599, 3601, 3568, 
3600, 2220, 3602
28, 845, 793, 798, 369, 3603, 3401, 3605, 
3604, 3606, 3607
29, 891, 896, 816, 537, 3608, 3612, 3610, 
3609, 3611, 3613
30, 204, 904, 493, 205, 3614, 3616, 2034, 
1153, 3615, 2036
31, 439, 893, 852, 892, 3617, 3621, 3619, 
3618, 3620, 3622
32, 237, 512, 587, 433, 2132, 2444, 2352, 
3623, 3624, 3625
33, 384, 841, 936, 933, 3626, 3630, 3628, 
3627, 3629, 3631
34, 713, 311, 685, 310, 3632, 3634, 2995, 
3633, 1259, 3635
35, 932, 124, 806, 125, 3636, 3415, 3638, 
3637, 1073, 3416
36, 486, 837, 935, 838, 3639, 3641, 3587, 
3591, 3640, 3589
37, 869, 916, 915, 878, 3642, 3644, 3560, 
3559, 3643, 3561
38, 158, 320, 404, 679, 3645, 3647, 1452, 
2888, 3646, 3648
39, 798, 849, 845, 369, 3649, 3651, 3605, 
3607, 3650, 3604
40, 888, 441, 472, 388, 3652, 1788, 3654, 
3653, 1653, 1789
41, 923, 786, 778, 783, 3655, 3326, 3657, 
3656, 3328, 3325
42, 838, 523, 524, 592, 3658, 2368, 3660, 
3659, 2487, 2493
43, 835, 397, 146, 147, 3661, 1436, 2214, 
2279, 1435, 1095
44, 486, 837, 459, 935, 3639, 3662, 1910, 
3587, 3641, 3663
45, 837, 524, 838, 900, 3664, 3660, 3640, 
3665, 3666, 3667
46, 15, 2, 22, 3, 2854, 966, 967, 
3668, 944, 2863
47, 935, 592, 839, 838, 3669, 3670, 3588, 
3589, 3659, 3592
48, 234, 347, 514, 245, 3671, 3673, 2305, 
2303, 3672, 2138
49, 137, 138, 768, 393, 1086, 3263, 3262, 
1424, 1423, 3674
50, 774, 773, 288, 601, 3282, 3278, 3280, 
3675, 3676, 2504
51, 888, 786, 923, 763, 3677, 3655, 3679, 
3678, 3334, 3680
52, 486, 837, 838, 446, 3639, 3640, 3591, 
1882, 3681, 3682
53, 798, 370, 794, 797, 3683, 3685, 3402, 
3374, 3684, 3403
54, 309, 846, 923, 848, 3686, 3690, 3688, 
3687, 3689, 3691
55, 193, 286, 919, 540, 2603, 3693, 3692, 
2313, 2203, 3564
56, 490, 494, 788, 796, 2067, 3697, 3695, 
3694, 3696, 3409
57, 215, 268, 49, 216, 2112, 3698, 1948, 
1164, 2113, 1949
58, 935, 592, 593, 839, 3669, 2459, 3699, 
3588, 3670, 3700
59, 523, 522, 844, 800, 2367, 3704, 3702, 
3701, 3703, 3705
60, 547, 295, 836, 868, 2218, 1864, 3707, 
3706, 3549, 3548
61, 698, 320, 637, 321, 3708, 2703, 3710, 
3709, 1269, 2704
62, 468, 869, 899, 487, 3711, 3714, 3712, 
1925, 3713, 3715
63, 319, 159, 679, 681, 3716, 2889, 3718, 
3717, 2893, 2895
64, 319, 320, 679, 404, 1268, 3646, 3718, 
3719, 3647, 3648
65, 824, 825, 932, 806, 1898, 3721, 3720, 
3474, 3475, 3638
66, 837, 610, 935, 838, 3722, 3724, 3641, 
3640, 3723, 3589
67, 741, 742, 903, 883, 3159, 3728, 3726, 
3725, 3727, 3729
68, 694, 660, 707, 700, 3730, 3732, 2974, 
2956, 3731, 2973
69, 932, 124, 805, 806, 3636, 3413, 3733, 
3638, 3415, 3417
70, 273, 272, 229, 62, 1221, 2340, 2126, 
3734, 3735, 1971
71, 479, 450, 559, 444, 1828, 3737, 3736, 
1859, 1908, 3738
72, 212, 250, 249, 40, 2149, 1198, 2107, 
3739, 3052, 3053
73, 45, 212, 249, 40, 1941, 2107, 3740, 
1312, 3739, 3053
74, 804, 378, 123, 805, 3741, 1394, 3411, 
3414, 3742, 3412
75, 285, 919, 925, 193, 3743, 3745, 3744, 
2082, 3692, 3746
76, 846, 154, 405, 680, 3747, 1453, 3749, 
3748, 2892, 3750
77, 904, 206, 205, 503, 3751, 1154, 3615, 
3752, 2097, 2096
78, 267, 116, 49, 268, 3071, 1675, 3753, 
1216, 3070, 3698
79, 894, 537, 891, 818, 3754, 3609, 3756, 
3755, 3757, 3758
80, 721, 720, 421, 873, 3086, 3762, 3760, 
3759, 3761, 3763
81, 680, 858, 405, 848, 3764, 3766, 3750, 
3765, 3581, 3767
82, 267, 268, 49, 215, 1216, 3698, 3753, 
2479, 2112, 1948
83, 820, 539, 282, 821, 3768, 2201, 3455, 
3460, 3769, 3457
84, 308, 846, 845, 591, 3770, 3773, 3771, 
2400, 3772, 3774
85, 105, 792, 367, 368, 3356, 3553, 1369, 
1372, 3775, 1577
86, 729, 596, 897, 728, 3776, 3779, 3777, 
3109, 3778, 3780
87, 303, 510, 834, 509, 2617, 3781, 2571, 
2232, 2123, 3782
88, 604, 479, 559, 444, 3783, 3736, 2532, 
3784, 1859, 3738
89, 931, 844, 800, 523, 3552, 3705, 3786, 
3785, 3702, 3701
90, 362, 583, 502, 201, 3787, 2436, 3789, 
3788, 2322, 2092
91, 940, 853, 323, 934, 3536, 3534, 3535, 
3790, 3791, 3792
92, 903, 203, 910, 338, 3793, 3796, 3795, 
3794, 2094, 3797
93, 642, 650, 624, 691, 2743, 2742, 2725, 
3798, 3799, 3800
94, 263, 109, 262, 526, 3068, 3055, 1211, 
2168, 3801, 2169
95, 866, 372, 400, 868, 3566, 1886, 3802, 
3568, 3570, 3803
96, 694, 660, 641, 669, 3730, 2773, 3805, 
3804, 2810, 2809
97, 429, 352, 42, 505, 1515, 1314, 1516, 
3806, 3807, 3808
98, 522, 845, 521, 591, 3809, 3810, 2366, 
2577, 3774, 2588
99, 682, 635, 702, 681, 3811, 3813, 2959, 
2898, 3812, 2958
100, 726, 742, 725, 883, 3150, 3149, 3100, 
3814, 3727, 3815
101, 251, 46, 250, 213, 3816, 3817, 1199, 
2301, 1943, 2296
102, 845, 798, 799, 521, 3605, 3377, 3818, 
3810, 3819, 3820
103, 904, 493, 96, 882, 3616, 2024, 3822, 
3821, 3823, 3824
104, 279, 818, 816, 537, 3448, 3450, 3444, 
2194, 3757, 3613
105, 444, 319, 404, 559, 3825, 3719, 1877, 
3738, 2249, 3826
106, 923, 591, 924, 847, 3827, 3831, 3829, 
3828, 3830, 3832
107, 868, 400, 866, 832, 3803, 3802, 3568, 
3547, 3833, 3834
108, 868, 296, 832, 866, 3599, 2640, 3547, 
3568, 3601, 3834
109, 450, 463, 355, 560, 1879, 1918, 1801, 
3835, 3836, 3837
110, 192, 857, 191, 83, 3838, 3839, 1140, 
2005, 3513, 2004
111, 942, 705, 629, 654, 3840, 3844, 3842, 
3841, 3843, 2754
112, 354, 224, 57, 396, 3845, 1962, 1327, 
1667, 3846, 1529
113, 319, 406, 444, 404, 3847, 1871, 3825, 
3719, 1627, 1877
114, 109, 120, 373, 263, 1069, 1384, 1383, 
3068, 3067, 3848
115, 891, 830, 818, 816, 3849, 1773, 3758, 
3610, 3496, 3450
116, 19, 623, 13, 24, 3850, 2664, 3851, 
2879, 3852, 2862
117, 822, 377, 804, 826, 3853, 3855, 3466, 
3478, 3854, 3490
118, 510, 58, 225, 430, 3856, 2048, 2122, 
3857, 1532, 3858
119, 847, 475, 441, 846, 3859, 1807, 3861, 
3860, 3862, 3863
120, 41, 518, 249, 211, 3864, 2145, 3054, 
3865, 2148, 2106
121, 384, 385, 129, 812, 1608, 1408, 1405, 
3866, 3867, 3432
122, 384, 812, 129, 811, 3866, 3432, 1405, 
3868, 2648, 3430
123, 942, 654, 710, 705, 3841, 3870, 3869, 
3840, 3843, 3019
124, 767, 860, 774, 929, 3871, 3874, 3311, 
3872, 3873, 3875
125, 307, 523, 840, 592, 2477, 3877, 3876, 
2409, 2487, 3878
126, 391, 84, 925, 865, 1556, 3882, 3880, 
3879, 3881, 3883
127, 396, 224, 56, 223, 3846, 1961, 1527, 
3884, 1172, 2046
128, 358, 900, 789, 930, 3885, 3889, 3887, 
3886, 3888, 3890
129, 880, 618, 879, 573, 3891, 3894, 3893, 
3892, 2610, 3895
130, 933, 384, 811, 936, 3627, 3868, 3896, 
3631, 3628, 3897
