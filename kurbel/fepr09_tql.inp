*Heading
Kurbel, parabolische Tetraeder, grobes Netz
*Node
1, 20, 300, -148.6607
2, 20, 360, -148.6607
3, 92.358482, 360, -117.2324
4, 143.33634, 360, -41.925887
5, 138.31134, 360, 55.305715
6, 91.731073, 360, 117.79672
7, 20, 360, 148.6607
8, -20, 300, -148.6607
9, -20, 360, -148.6607
10, -91.266145, 360, -118.21489
11, -140.03512, 360, -50.715894
12, -142.71279, 360, 43.586205
13, -88.724252, 360, 120.50119
14, -20, 360, 148.6607
15, 20, 300, -93.89356
16, -20, 300, -93.89356
17, -20, 300, 148.6607
18, 20, 300, 148.6607
19, -20, 300, 93.89356
20, 20, 300, 93.89356
21, 20, 360, 93.89356
22, 20, 360, -93.89356
23, -20, 360, 93.89356
24, -74.866156, 360, 58.682507
25, -95.217951, 360, -5.7109261
26, -69.084239, 360, -65.82573
27, -20, 360, -93.89356
28, 71.041083, 360, 63.408162
29, 95.841413, 360, 1.1580852
30, 72.752122, 360, -61.294274
31, 480.1787, 0, -79.57472
32, 452.13899, 0, -17.616045
33, 460.96067, 0, 48.424311
34, 507.06705, 0, 101.50551
35, 571.34026, 0, 119.1251
36, 635.30647, 0, 100.2598
37, 678.61681, 0, 49.538403
38, 687.79574, 0, -18.153584
39, 660.2469, 0, -78.958131
40, 603.67482, 0, -114.3901
41, 537.05264, 0, -114.56941
42, 258.5671, 0, -247.9106
43, 377.48106, 0, -225.46844
44, 506.60134, 0, -203.72946
45, 600.28815, 0, -190.0411
46, 695.85464, 0, -178.74399
47, 802.41795, 0, -167.66123
48, 884.67202, 0, -161.75826
49, 961.63615, 0, -156.96664
50, 1038.6488, 0, -153.34461
51, 1106.1841, 0, -151.94468
52, 1195.4787, 0, -150.09372
53, 1266.3078, 0, -134.37567
54, 1315.1138, 0, -95.684581
55, 1346.2671, 0, -33.128863
56, 1346.1326, 0, 33.682338
57, 1317.8225, 0, 92.652105
58, 1272.2102, 0, 130.66682
59, 1208.2945, 0, 149.06544
60, 1129.6044, 0, 151.45921
61, 1053.7734, 0, 153.03109
62, 960.81306, 0, 157.01788
63, 883.84893, 0, 161.8095
64, 803.03953, 0, 167.59659
65, 697.67545, 0, 178.55462
66, 600.66515, 0, 189.98602
67, 506.97835, 0, 203.67438
68, 386.93064, 0, 223.68506
69, 258.47725, 0, 247.93145
70, 170.49539, 0, 268.34483
71, 110.06778, 0, 282.36513
72, 64.864225, 0, 292.33782
73, 24.134217, 0, 298.69251
74, -11.508876, 0, 299.45082
75, -51.639739, 0, 294.9281
76, -97.903915, 0, 283.07542
77, -148.05641, 0, 260.74514
78, -181.60501, 0, 238.51352
79, -210.51285, 0, 212.91478
80, -235.45363, 0, 184.5873
81, -260.27028, 0, 147.52391
82, -283.34665, 0, 97.029855
83, -295.81429, 0, 48.52736
84, -299.14166, 0, 11.300243
85, -298.15815, 0, -24.248493
86, -293.28286, 0, -59.464879
87, -281.47006, 0, -101.74103
88, -260.72164, 0, -146.75479
89, -235.69148, 0, -184.29456
90, -209.43141, 0, -213.89601
91, -180.46871, 0, -239.26652
92, -136.18014, 0, -266.59433
93, -90.859462, 0, -285.1162
94, -50.179042, 0, -295.1196
95, -14.817673, 0, -299.52121
96, 20.8254, 0, -298.76291
97, 60.210435, 0, -293.15056
98, 111.2229, 0, -282.09712
99, 172.7687, 0, -267.81738
100, -182.4335, 0, 182.4335
101, -163.89504, 0, 190.68826
102, -144.54217, 0, 185.46374
103, -132.81647, 0, 169.2445
104, -133.94669, 0, 149.07726
105, -148.70031, 0, 134.19855
106, -168.79984, 0, 132.72802
107, -185.21187, 0, 144.16521
108, -190.77671, 0, 163.45037
109, 836.3604, 0, 63.63961
110, 884.19858, 0, 87.919699
111, 930.10913, 0, 84.11028
112, 968.63281, 0, 57.13234
113, 988.1004, 0, 14.428785
114, 984.5195, 0, -29.121167
115, 959.83335, 0, -66.560252
116, 922.99118, 0, -86.973148
117, 877.49099, 0, -87.036627
118, 837.4813, 0, -64.499706
119, 813.69833, 0, -24.818612
120, 812.57749, 0, 19.577827
121, -27.02907, 0, 241.0165
122, -14.082543, 0, 253.68081
123, 4.2293332, 0, 257.2478
124, 20.520837, 0, 249.17753
125, 28.745176, 0, 233.49775
126, 26.978642, 0, 214.92027
127, 13.792165, 0, 202.17935
128, -4.1360252, 0, 198.7522
129, -20.229919, 0, 206.45767
130, -28.641349, 0, 222.04736
131, -251.4549, 0, 18.70469
132, -236.28299, 0, 28.109462
133, -218.71497, 0, 27.880753
134, -204.01817, 0, 17.610513
135, -198.7522, 0, -0.51389923
136, -204.30215, 0, -18.20021
137, -218.80719, 0, -27.901802
138, -237.64896, 0, -27.797688
139, -252.62968, 0, -16.26523
140, -257.2478, 0, 0.70054379
141, 1097.574, 0, 42.42641
142, 1134.3091, 0, 59.250772
143, 1185.9497, 0, 60
144, 1224.1723, 0, 54.375415
145, 1251.9302, 0, 30.041378
146, 1259.8182, 0, -1.3812661
147, 1250.1939, 0, -32.304051
148, 1223.8163, 0, -54.522871
149, 1186.5742, 0, -60
150, 1139.7295, 0, -59.964394
151, 1104.0912, 0, -47.427358
152, 1084.1399, 0, -20.589132
153, 1081.8237, 0, 13.855659
154, -83.13844, 0, 48
155, -38.513508, 0, 87.067874
156, 8.4828827, 0, 94.883208
157, 52.041274, 0, 80.037461
158, 84.735007, 0, 44.145545
159, 93.64135, 0, -17.915727
160, 61.057052, 0, -73.11941
161, 5.5732081, 0, -95.266273
162, -39.708666, 0, -86.572823
163, -76.577402, 0, -56.55051
164, -95.339411, 0, -5.0176748
165, -182.4335, 0, -140.0071
166, -163.99384, 0, -131.77201
167, -144.70971, 0, -136.86496
168, -132.87544, 0, -152.89967
169, -133.72279, 0, -173.02824
170, -147.71595, 0, -187.5844
171, -167.76226, 0, -189.91903
172, -185.07192, 0, -178.48484
173, -190.66861, 0, -158.44673
174, -27.02907, 0, -214.9835
175, -14.628544, 0, -202.58213
176, 3.3059375, 0, -198.7522
177, 19.832867, 0, -205.95978
178, 28.666479, 0, -222.15746
179, 27.314339, 0, -239.76665
180, 14.024982, 0, -253.70853
181, -3.0947689, 0, -257.2478
182, -19.920475, 0, -249.93036
183, -28.744086, 0, -233.50252
184, -61.41276, 60, 293.6469
185, -109.03636, 60, 279.16165
186, -157.33903, 60, 254.59384
187, -188.58731, 60, 232.80876
188, -217.44751, 60, 206.62266
189, -241.56261, 60, 177.06852
190, -267.81995, 60, 134.65906
191, -288.00263, 60, 82.279183
192, -297.20239, 60, 36.83127
193, -299.92571, 60, 0.97810078
194, -297.35098, 60, -34.875068
195, -290.5773, 60, -71.154813
196, -275.32682, 60, -117.16361
197, -252.77162, 60, -160.30186
198, -227.74404, 60, -194.07606
199, -199.32297, 60, -223.06784
200, -167.75054, 60, -247.69445
201, -121.03345, 60, -273.60711
202, -74.549899, 60, -289.84108
203, -36.887794, 60, -296.86203
204, -1.110491, 60, -299.22959
205, 34.753253, 60, -297.59645
206, 78.445071, 60, -289.70217
207, 135.78104, 60, -276.39919
208, 202.73, 60, -260.86582
209, 285.10014, 60, -242.90312
210, 394.4389, 60, -222.26806
211, 516.05575, 60, -202.3481
212, 610.54487, 60, -188.54252
213, 709.45103, 60, -177.32994
214, 814.78841, 60, -166.37468
215, 895.07528, 60, -161.11057
216, 972.74397, 60, -156.27509
217, 1049.7624, 60, -153.11424
218, 1118.7672, 60, -151.68385
219, 1211.8425, 60, -148.66567
220, 1275.2611, 60, -128.74975
221, 1322.6551, 60, -84.960796
222, 1347.8006, 60, -19.519143
223, 1343.5808, 60, 40.974772
224, 1313.123, 60, 97.675352
225, 1265.9561, 60, 134.59669
226, 1206.5001, 60, 149.26761
227, 1130.9317, 60, 151.4317
228, 1052.4707, 60, 153.0581
229, 958.8652, 60, 157.13915
230, 881.24197, 60, 161.97181
231, 798.89316, 60, 168.02781
232, 691.80115, 60, 179.16556
233, 595.08479, 60, 190.80135
234, 500.59567, 60, 204.60694
235, 378.97782, 60, 225.18597
236, 242.80846, 60, 251.56689
237, 158.65484, 60, 271.09205
238, 101.92095, 60, 284.25534
239, 56.324092, 60, 293.82928
240, 17.142327, 60, 298.84126
241, -18.785757, 60, 299.23513
242, 676.2547, 60, 55.76678
243, 629.40822, 60, 103.35542
244, 564.67901, 60, 119.1251
245, 501.2714, 60, 98.261235
246, 458.59855, 60, 42.195934
247, 452.94192, 60, -24.228725
248, 485.16472, 60, -83.991948
249, 543.52032, 60, -116.16357
250, 610.1425, 60, -112.79594
251, 664.03092, 60, -73.476026
252, 688.59867, 60, -11.540904
253, -172.7008, 60, 188.9367
254, -187.42157, 60, 174.96835
255, -189.91233, 60, 154.64463
256, -179.12644, 60, 137.79742
257, -159.99411, 60, 131.46421
258, -141.23514, 60, 139.18656
259, -131.90782, 60, 157.76402
260, -136.53418, 60, 177.23585
261, -152.41453, 60, 189.46873
262, 855, 60, 77.94229
263, 820.72437, 60, 41.781047
264, 810.79387, 60, -6.0300175
265, 823.02535, 60, -46.261059
266, 856.41215, 60, -78.52722
267, 904.09107, 60, -89.4614
268, 944.6617, 60, -78.082417
269, 976.80021, 60, -46.4884
270, 989.16872, 60, -6.314129
271, 979.51172, 60, 41.211066
272, 947.87999, 60, 75.732391
273, 907.37435, 60, 89.029146
274, -18.70469, 60, 251.4549
275, -28.304659, 60, 235.42778
276, -27.428876, 60, 216.73516
277, -15.743945, 60, 203.11928
278, 1.5964273, 60, 198.7522
279, 18.879241, 60, 204.76398
280, 28.159298, 60, 219.93535
281, 27.518865, 60, 238.87057
282, 16.164332, 60, 252.67827
283, -1.503119, 60, 257.2478
284, -241.0165, 60, 27.02907
285, -253.48053, 60, 14.498429
286, -257.2478, 60, -4.1546978
287, -249.77581, 60, -20.043728
288, -232.91545, 60, -28.87808
289, -214.4776, 60, -26.625626
290, -202.19554, 60, -13.825789
291, -198.7522, 60, 4.3413438
292, -207.39158, 60, 20.974695
293, -223.44848, 60, 28.961145
294, 1110, 60, 51.96152
295, 1086.8864, 60, 27.219884
296, 1080.7955, 60, -6.0438991
297, 1093.4368, 60, -37.035246
298, 1123.1696, 60, -57.41648
299, 1166.6832, 60, -60
300, 1208.8424, 60, -58.835869
301, 1240.7464, 60, -43.71526
302, 1258.1511, 60, -14.047119
303, 1257.127, 60, 17.530589
304, 1238.1454, 60, 45.711141
305, 1202.4662, 60, 59.675309
306, 1157.5238, 60, 60
307, -93.52347, 60, 117.2747
308, -123.76124, 60, 83.200192
309, -144.50431, 60, 38.336159
310, -149.63875, 60, 3.2062235
311, -146.37358, 60, -32.185447
312, -134.09441, 60, -66.75505
313, -106.17264, 60, -104.62553
314, -69.803754, 60, -132.17878
315, -25.279103, 60, -147.15174
316, 10.112572, 60, -148.86059
317, 45.746754, 60, -141.91122
318, 95.647129, 60, -115.15104
319, 141.55861, 60, -46.75444
320, 144.78204, 60, 37.542436
321, 101.52358, 60, 109.27459
322, 57.335908, 60, 137.85598
323, 18.831764, 60, 147.87818
324, -14.449587, 60, 148.37193
325, -59.207677, 60, 137.20102
326, -172.7008, 60, -133.504
327, -187.36561, 60, -147.38851
328, -190.04008, 60, -167.1537
329, -179.00075, 60, -184.7272
330, -159.05531, 60, -190.78966
331, -140.33455, 60, -182.65229
332, -131.84885, 60, -164.3801
333, -136.64614, 60, -145.0372
334, -152.51338, 60, -132.95228
335, -18.70469, 60, -204.5451
336, -27.994263, 60, -219.21229
337, -27.737362, 60, -237.91327
338, -16.782917, 60, -252.38038
339, 1.4294145, 60, -257.2478
340, 18.054149, 60, -251.76818
341, 28.321063, 60, -235.35591
342, 27.659754, 60, -217.74671
343, 16.65632, 60, -203.55866
344, -1.2182449, 60, -198.7522
345, 396.16027, 0, -64.140614
346, 378.20872, 0, 36.194775
347, 428.75678, 0, 123.2709
348, 439.87167, 0, -140.12498
349, 721.35267, 0, 99.375764
350, 730.04357, 0, 23.004728
351, 736.47401, 0, -76.274706
352, 310.03412, 0, -135.49194
353, 1002.6018, 0, -89.088999
354, 1266.6359, 0, 70.077563
355, 198.06733, 0, 185.51026
356, 79.523336, 0, 251.65457
357, -69.276296, 0, 255.27384
358, -144.45032, 0, 212.95481
359, -232.48024, 0, 114.28056
360, -265.44181, 0, -34.59736
361, -230.78182, 0, -107.93351
362, -107.27886, 0, -232.33702
363, 33.840968, 0, -267.88743
364, 124.66642, 0, -222.25503
365, -122.2579, 0, 189.29738
366, -110.30616, 0, 158.78665
367, -122.25384, 0, 118.56141
368, -160.66207, 0, 111.01577
369, -191.23018, 0, 122.90941
370, -214.0996, 0, 147.11372
371, 1017.4242, 0, 48.999731
372, 1024.1517, 0, -0.45693721
373, 780.86407, 0, 69.607212
374, 791.62332, 0, -55.730463
375, 774.98102, 0, -6.8168801
376, -33.636699, 0, 265.14996
377, -3.8825596, 0, 275.05279
378, 18.406709, 0, 269.7438
379, 44.246699, 0, 259.89311
380, 53.094252, 0, 229.21657
381, -47.68085, 0, 235.98692
382, 32.932622, 0, 191.37091
383, 9.9482311, 0, 180.02516
384, -29.779446, 0, 186.90611
385, -44.5654, 0, 209.20621
386, -255.20689, 0, 41.216978
387, -228.50248, 0, 46.658643
388, -204.64724, 0, 41.520444
389, -184.26996, 0, 14.639025
390, -183.84096, 0, -14.707251
391, -271.92044, 0, 18.290015
392, -202.75953, 0, -43.497315
393, -223.82817, 0, -48.846066
394, -274.50471, 0, -8.6371676
395, 1075.2103, 0, 84.62597
396, 1295.8308, 0, 24.988323
397, 1292.9416, 0, -24.962439
398, 1057.3123, 0, 32.475408
399, 1051.8651, 0, -51.232671
400, 1057.5282, 0, -5.904982
401, -16.736232, 0, 129.16832
402, 40.034622, 0, 126.99827
403, 101.24059, 0, 93.248479
404, 153.22242, 0, 23.986748
405, -133.15497, 0, 19.71079
406, 131.94027, 0, -85.980544
407, 57.066765, 0, -124.61462
408, -22.506745, 0, -123.7109
409, -90.226554, 0, -99.484716
410, -133.83523, 0, -48.298725
411, -185.2619, 0, -114.79428
412, -151.4938, 0, -115.30565
413, -120.70212, 0, -130.9545
414, -111.78547, 0, -164.45604
415, -211.90824, 0, -142.37547
416, -125.47144, 0, -193.75173
417, -147.87924, 0, -216.29684
418, -31.259469, 0, -193.75529
419, -11.929928, 0, -184.66571
420, 19.058783, 0, -186.08721
421, 38.729805, 0, -209.84385
422, 46.028371, 0, -225.85659
423, -51.432814, 0, -222.11784
424, 6.1986129, 0, -276.1735
425, -19.448216, 0, -273.04375
426, -39.772023, 0, -260.3821
427, 998.73658, 0, 101.97222
428, 810.51009, 0, -100.72672
429, 187.36625, 0, -172.796
430, 1229.8035, 0, 93.888902
431, 835.53776, 0, 114.36099
432, 310.85989, 0, 144.46432
433, 126.91434, 0, 233.80179
434, -108.10384, 0, 229.65733
435, -244.75738, 0, 76.34449
436, -248.41764, 0, -64.111561
437, -70.159193, 0, -261.71008
438, 68.137546, 0, -243.32304
439, 54.860111, 0, 201.91798
440, -12.954555, 0, 168.72194
441, -175.04964, 0, 36.976977
442, 40.056024, 0, -188.24258
443, -53.49335, 0, -200.81574
444, 217.62483, 0, -57.411391
445, 126.38579, 0, 182.46475
446, -93.583244, 0, 191.01142
447, -177.47616, 0, -0.1957217
448, 4.3290565, 0, -175.92809
449, -51.931827, 0, -242.19978
450, 246.7498, 0, 65.291567
451, 87.391774, 0, 216.85064
452, -196.04161, 0, 93.201483
453, 113.9227, 0, -164.97456
454, -71.905516, 0, 219.7445
455, -206.53564, 0, -76.502141
456, -158.67427, 0, -13.085834
457, 24.088927, 0, -158.11591
458, -163.76007, 0, 12.906098
459, -60.810599, 0, 189.18004
460, 31.139568, 0, 163.40618
461, -212.3448, 0, 65.057627
462, 94.394093, 0, 143.52895
463, 156.9273, 0, 118.32148
464, -130.40257, 0, -94.763744
465, -84.353049, 0, -137.44821
466, -101.23374, 0, -193.71453
467, -164.62532, 0, -87.869371
468, -29.417656, 0, -172.52227
469, 61.568393, 0, -208.00633
470, 57.669743, 0, 168.02952
471, -78.703885, 0, -175.51628
472, -186.14685, 0, 62.949672
473, -178.0993, 0, -33.93543
474, -73.881508, 0, -233.71503
475, -148.91517, 0, 75.473755
476, -73.918063, 0, 132.7868
477, -78.463246, 0, -208.91749
478, 7.305487, 0, 152.09746
479, 310.98939, 0, -31.790732
480, -44.388235, 0, 160.39089
481, 90.34529, 0, -203.99147
482, -11.440626, 0, -157.3999
483, -50.40062, 0, -179.89449
484, -177.89382, 0, -60.069378
485, 68.044284, 0, -173.88113
486, -78.018438, 0, 165.87497
487, -47.86974, 0, -151.56518
488, 85.706541, 0, 183.57341
489, -165.60463, 28.961152, 249.11648
490, -222.20694, 28.056417, 200.89098
491, -297.09885, 31.397988, -38.19441
492, -205.32425, 29.052388, -217.62261
493, -7.9366693, 30.116216, -299.37482
494, -197.68748, 29.724883, 224.55179
495, -80.656772, 60, 247.362
496, -154.50721, 60, 213.91801
497, -230.27446, 60, 137.43297
498, -255.53717, 60, 65.100827
499, -273.42285, 60, -53.410619
500, -251.31024, 60, -89.828944
501, -213.89883, 60, -153.30118
502, -84.983704, 60, -248.71774
503, 56.614664, 60, -257.64969
504, 153.72486, 60, -210.74852
505, 236.78864, 60, -178.97756
506, 339.94125, 60, -152.07065
507, 736.15983, 60, -94.273706
508, 1089.9096, 60, -104.91112
509, 1294.5543, 60, 5.8377792
510, 1270.6059, 60, 67.672153
511, 290.52586, 60, 123.06854
512, 118.62635, 60, 229.9714
513, 33.825249, 60, 272.02603
514, 421.61972, 60, 120.06142
515, 390.20372, 60, 31.408035
516, 757.05476, 60, 30.210827
517, 389.45925, 60, -68.007197
518, 447.8377, 60, -143.02639
519, -211.43868, 60, 165.33329
520, -203.19355, 60, 140.48664
521, -170.84532, 60, 113.32352
522, -139.92704, 60, 113.66537
523, -115.50035, 60, 143.72258
524, -114.26996, 60, 178.17593
525, -134.17254, 60, 196.63784
526, 789.97314, 60, 87.453651
527, 769.74114, 60, -34.742251
528, 1017.3892, 60, -37.827617
529, 1021.3817, 60, 13.738052
530, 1017.8259, 60, 77.440002
531, -47.591199, 60, 253.25139
532, -53.765113, 60, 227.46194
533, -31.062787, 60, 194.87769
534, -12.848725, 60, 181.33428
535, 16.791759, 60, 181.29638
536, -12.140973, 60, 270.8043
537, 39.076721, 60, 204.59842
538, 40.684026, 60, 226.42146
539, 8.0272317, 60, 274.59643
540, -272.30024, 60, -22.879823
541, -253.31846, 60, -37.86896
542, -219.83424, 60, -44.843054
543, -233.74186, 60, 46.763086
544, -186.23229, 60, -32.222525
545, -177.8174, 60, -6.6691055
546, -180.70175, 60, 23.992699
547, 1076.4556, 60, 79.876341
548, 1054.6515, 60, 26.94986
549, 1056.721, 60, -25.755261
550, 1083.0579, 60, -61.668252
551, 1124.4101, 60, 87.841912
552, 1244.378, 60, -83.884858
553, 1283.5957, 60, -48.981448
554, -169.94897, 60, -62.922085
555, -59.20917, 60, -171.87039
556, 44.366016, 60, -169.69979
557, 97.859163, 60, -170.59394
558, 174.67766, 60, -121.31872
559, 219.03701, 60, 3.5318421
560, 178.48596, 60, 109.11282
561, 108.96221, 60, 173.18475
562, 56.030837, 60, 183.10125
563, -195.80954, 60, -122.69773
564, -161.78803, 60, -97.548841
565, -136.63689, 60, -202.14753
566, -120.31252, 60, -183.32705
567, -115.55854, 60, -137.61935
568, -143.0315, 60, -118.54208
569, -44.338429, 60, -200.93037
570, -44.882798, 60, -223.31205
571, 16.825288, 60, -273.39181
572, -18.551298, 60, -179.67573
573, 53.873491, 60, -229.43691
574, 32.228291, 60, -203.96206
575, 11.261919, 60, -179.09766
576, -47.524414, 60, -263.5011
577, 721.03009, 60, 105.96696
578, 1008.9301, 60, -97.790693
579, -118.37954, 60, 222.46825
580, -243.34938, 60, 101.17865
581, -232.0235, 60, -121.92021
582, -164.02525, 60, -211.88102
583, -130.20422, 60, -231.64571
584, 93.223249, 60, -237.41522
585, 1167.9747, 60, 102.37367
586, 72.673161, 60, 251.87885
587, 178.68933, 60, 195.18084
588, -201.98765, 60, 110.84453
589, 799.1419, 60, -86.840086
590, -256.30653, 60, 37.996423
591, -172.80091, 60, 77.002291
592, -87.303722, 60, 160.17313
593, -47.108044, 60, 172.93429
594, -49.796227, 60, 202.69175
595, -199.64098, 60, -53.731248
596, -54.186662, 60, -241.82076
597, -94.77055, 60, -201.69193
598, -32.017448, 60, 273.33868
599, -203.38784, 60, -90.763903
600, 314.74874, 60, -1.9086559
601, -235.67827, 60, -48.063029
602, -99.972388, 60, -166.30002
603, 28.145319, 60, -188.77149
604, 278.85842, 60, -85.241789
605, 59.643486, 60, 221.79277
606, 43.375246, 60, 246.34524
607, -206.86, 60, 44.970254
608, 46.946071, 60, -211.4568
609, 33.600971, 60, -261.26727
610, -82.666296, 60, 200.2523
611, 45.143283, 60, -193.66811
612, -224.52858, 60, -68.725637
613, -68.216052, 60, -220.97365
614, 1049.744, 60, -67.75383
615, -219.96673, 60, 73.937159
616, 85.410895, 60, 212.21624
617, -248.27031, 60, -62.533259
618, 69.233581, 60, -200.8399
619, 148.74407, 277.09911, 11.024311
620, -12.50315, 228.35033, -149.19695
621, -124.30738, 284.08738, -82.343295
622, -148.47264, 287.51531, 13.206204
623, -111.34652, 283.1211, 100.09113
624, 17.987901, 242.67867, 148.66907
625, -107.3663, 101.36854, 103.55044
626, -132.56285, 101.69779, 69.307298
627, -147.15592, 102.46075, 25.241973
628, -148.29675, 103.57831, -15.116828
629, -138.85881, 101.36704, -54.568844
630, -118.29429, 96.056119, -91.888676
631, -86.575509, 97.34487, -121.74953
632, -46.254415, 103.54595, -141.86314
633, -6.8985746, 98.424701, -149.36908
634, 35.907774, 97.13242, -145.45388
635, 83.836718, 105.68758, -123.49481
636, 149.3433, 134.53091, 5.8283595
637, 125.54012, 126.14695, 80.551233
638, 79.869751, 110.40529, 126.00121
639, 4.3481032, 94.272641, 149.64063
640, -33.282819, 93.685056, 146.12956
641, 118.37063, 277.29924, -91.070313
642, 105.33426, 272.74105, 105.87845
643, -75.064967, 98.748187, 128.98619
644, 129.15457, 125.12496, -74.79605
645, 39.393787, 92.138493, 144.22985
646, -80.734056, 233.59123, -125.81815
647, -47.904304, 242.259, 141.69853
648, 32.054884, 136.78398, 146.26821
649, -147.8485, 221.73344, -18.858884
650, 77.6639, 187.79535, 127.61341
651, -140.07427, 144.56046, 51.198468
652, -149.04537, 157.17342, 8.4725741
653, -144.46324, 155.3834, -38.681405
654, -127.22869, 144.97334, -77.91571
655, -101.12568, 132.91686, -109.88148
656, -63.877777, 159.37347, -135.4437
657, -19.800032, 152.04873, -148.11969
658, 19.571243, 133.96537, -148.07659
659, 59.980232, 144.1901, -137.18118
660, 61.403879, 239.51648, -136.49143
661, -48.520025, 131.3549, 141.15311
662, -93.831709, 205.12508, 116.4701
663, -83.895422, 148.07026, 123.58179
664, -119.56595, 151.41649, 89.809205
665, -11.345851, 128.0286, 148.98075
666, -138.50335, 211.23741, 55.462304
667, 139.94198, 203.7584, 51.665309
668, -22.772693, 182.65545, 147.90133
669, 100.61219, 184.07468, -110.4479
670, -128.81649, 210.19672, -75.568315
671, 35.57268, 187.74767, -145.17878
672, 144.91847, 202.08714, -37.492023
673, -103.51723, 180.49113, -107.62627
674, 0.34376135, 257.84142, -95.798188
675, -10.679178, 253.76603, 95.131949
676, -79.992785, 293.3257, -52.420352
677, -85.538219, 259.81792, 41.998008
678, 73.199552, 52.119638, 61.009619
679, 95.043449, 57.76247, 7.2657256
680, -90.51215, 49.545973, 30.243244
681, 78.136962, 58.181664, -54.581694
682, 29.905872, 52.553549, -90.702527
683, -20.823192, 47.499222, -93.361273
684, -67.690093, 46.164799, -68.046358
685, -92.966862, 46.520751, -22.98481
686, 79.645803, 302.5956, -52.868665
687, 78.790534, 291.21855, 53.943362
688, -58.39424, 51.798752, 75.225076
689, -14.82372, 40.740393, 94.136505
690, 29.965141, 47.712012, 90.671597
691, 40.585212, 252.90455, 86.543017
692, -48.325658, 247.00487, -82.520534
693, 75.003821, 219.52052, 58.735454
694, 52.693473, 247.89646, -79.41311
695, 15.792024, 205.53277, 94.334374
696, -86.201016, 229.91971, -40.518128
697, 94.566746, 251.01333, -10.756753
698, 86.907121, 110.3963, 39.001766
699, 51.107771, 94.248087, 80.781042
700, 0.99143509, 210.65436, -95.835121
701, -8.7895847, 94.369464, 95.046865
702, 45.221934, 113.25165, -84.438392
703, -9.4034914, 99.937594, -94.978082
704, -51.055402, 86.431541, -80.830508
705, -83.990956, 96.395251, -45.860642
706, 91.0233, 119.16902, -29.07239
707, 65.1227, 182.89974, -70.220124
708, 94.347636, 174.00779, 12.550952
709, -54.062896, 188.61012, -78.532015
710, -93.948136, 159.76438, -15.517298
711, -40.255245, 209.54687, 86.622558
712, -75.59387, 113.60162, 57.956537
713, -95.545746, 95.745869, 3.4504044
714, -4.8453865, 155.5699, -95.69845
715, 49.568829, 153.13572, 81.783308
716, -25.819286, 157.16429, 92.089254
717, -54.625347, 132.74551, -78.214592
718, -75.504616, 178.01368, 58.143312
719, -2.3246017, 21.299998, -198.7522
720, 14.717518, 16.048209, -202.62498
721, 27.60263, 15.190986, -217.49643
722, 28.610541, 15.027923, -234.08762
723, -28.761763, 18.06873, -222.57493
724, 20.536971, 14.579469, -249.1573
725, 3.0606368, 14.757156, -257.2478
726, -14.199338, 16.793129, -253.62457
727, -27.341921, 18.513425, -239.64581
728, -29.647141, 39.249954, -229.54598
729, -20.602935, 37.888747, -249.07459
730, -4.0058921, 43.762547, -257.2478
731, 13.747525, 44.37081, -253.84215
732, -13.277573, 39.8703, -201.93153
733, 27.396665, 44.873093, -239.40596
734, 28.812814, 45.280965, -222.7986
735, 21.417359, 45.667257, -207.94667
736, 4.4793041, 43.674661, -198.7522
737, -20.131361, 18.385752, -206.33408
738, -24.638873, 46.283025, -211.9863
739, 24.76759, 30.716263, -212.1477
740, 29.902106, 30.193866, -227.5711
741, 9.6067364, 29.487712, -255.83625
742, -7.1784702, 29.091397, -257.00564
743, -25.227574, 32.257481, -212.7245
744, 13.107164, 31.459802, -201.84947
745, 24.153892, 29.84575, -244.62184
746, -174.29363, 20.300124, -134.56828
747, -153.01888, 21.007126, -132.85173
748, -135.05912, 20.959063, -147.41236
749, -132.78439, 20.421113, -169.08321
750, -148.0927, 17.988181, -187.83614
751, -174.04918, 19.019101, -188.03574
752, -189.00981, 19.138137, -172.33323
753, -189.06566, 19.458226, -150.3881
754, -180.83072, 39.751343, -138.93617
755, -190.6119, 39.042633, -158.16166
756, -184.58737, 38.803622, -179.21001
757, -166.18591, 38.350718, -190.23258
758, -143.74336, 39.085977, -184.92999
759, -132.29536, 40.790287, -166.62481
760, -138.10169, 42.981179, -142.85878
761, -160.46712, 40.543366, -131.37012
762, -224.54639, 16.624471, 29.211737
763, -208.73802, 14.991208, 22.048445
764, -198.7522, 14.419325, 6.1543381
765, -200.95995, 16.189657, -11.260068
766, -255.5492, 14.496426, 10.202802
767, -211.58815, 19.536056, -24.321357
768, -231.24969, 20.006061, -29.258279
769, -249.30725, 20.576458, -20.417387
770, -257.2478, 13.193642, -6.1249678
771, -257.2478, 44.235942, 5.0784941
772, -254.04116, 41.712678, -13.334269
773, -240.20623, 40.284748, -27.214009
774, -221.34339, 39.58476, -28.480672
775, -233.10398, 48.471894, 28.835051
776, -203.76493, 37.658682, -17.084661
777, -198.7522, 43.853868, -0.18208961
778, -203.37829, 45.009068, 16.281786
779, -218.44425, 45.313188, 27.818964
780, -244.3735, 16.665288, 24.351938
781, -247.53767, 45.430407, 21.828586
782, -257.2478, 27.640856, -1.8784589
783, -201.72107, 29.601665, 12.840537
784, -198.7522, 28.197932, -2.2449991
785, -252.61737, 30.229088, 16.290803
786, -213.25613, 30.631411, 25.651535
787, -233.81381, 32.685657, 28.673037
788, -174.15806, 20.294362, 187.96299
789, -152.88731, 20.996207, 189.56277
790, -134.96494, 20.89953, 174.88728
791, -132.82909, 20.519691, 153.13266
792, -146.11149, 19.818725, 135.92833
793, -167.42767, 19.633916, 132.45507
794, -186.30861, 17.369069, 145.80659
795, -189.04053, 19.703122, 172.17883
796, -180.30596, 39.418656, 183.85508
797, -190.73761, 39.272583, 163.64698
798, -183.35314, 38.824795, 141.38344
799, -164.6791, 39.599074, 131.90832
800, -143.99124, 40.094124, 137.34502
801, -132.30779, 40.956021, 155.75331
802, -138.00721, 43.14344, 179.44041
803, -160.24816, 40.501754, 191.02693
804, -2.696589, 15.711107, 257.2478
805, 15.505358, 15.187346, 252.99562
806, 27.660849, 15.369125, 238.24849
807, 28.353121, 14.534235, 220.78455
808, -28.729765, 18.630276, 233.56526
809, 18.483848, 14.613923, 204.43875
810, 2.5738952, 14.544927, 198.7522
811, -14.708125, 15.575168, 202.62045
812, -27.238758, 18.090187, 215.9022
813, -29.228809, 38.789095, 224.62119
814, -21.047803, 37.502461, 207.48326
815, -3.3789982, 43.889514, 198.7522
816, 13.874803, 44.929813, 202.21915
817, -10.860497, 47.381824, 255.23247
818, 27.144519, 45.107253, 215.48932
819, 28.885843, 45.204705, 232.88144
820, 21.076759, 45.337479, 248.48043
821, 4.4721839, 45.778527, 257.2478
822, -20.266396, 17.078147, 249.49659
823, -23.730453, 39.69043, 245.15282
824, 24.561662, 30.368948, 244.11052
825, 29.629901, 30.344296, 226.37849
826, -8.6093099, 32.235829, 256.31659
827, 9.1605728, 29.673304, 199.94889
828, -7.2079003, 28.367019, 199.00853
829, 10.264159, 31.07188, 255.51965
830, 22.943346, 30.347667, 209.86019
831, 1237.1525, 29.012243, -46.473048
832, 1081.3182, 30.779222, -10.014898
833, 1259.0487, 30.276461, 7.2272669
834, 1248.5579, 31.502922, 34.43589
835, 1254.9115, 30.166154, -22.879265
836, 1086.9985, 28.516307, 27.49038
837, -91.347034, 28.230911, 207.2742
838, -102.50203, 29.654636, 168.5556
839, -52.718731, 29.939839, 159.11361
840, -82.239721, 31.824767, 122.16895
841, -18.995707, 21.951112, 157.20442
842, 7.0449239, 27.63458, 130.91
843, -39.454514, 26.525273, 127.32835
844, -123.69266, 30.39471, 105.03992
845, -166.08776, 30.414169, 104.82673
846, -144.0423, 29.768408, 56.384821
847, -177.53621, 24.032852, 65.003802
848, -159.53639, 32.638471, 18.252011
849, -211.06825, 31.14202, 104.56214
850, -227.27452, 35.061001, 42.086186
851, 75.000992, 29.871641, 236.81458
852, 63.837052, 28.07059, 204.06275
853, 21.295197, 24.475251, 158.78665
854, 93.426909, 31.033731, 196.7726
855, 92.068032, 32.547631, 148.86887
856, 57.744704, 26.307266, 169.35529
857, -266.16258, 27.78098, 48.738461
858, -147.53583, 31.3448, -15.171504
859, -240.3706, 18.656724, 43.595031
860, -221.843, 32.396462, -59.893556
861, -164.94854, 30.063905, -47.719075
862, -190.72332, 30.660621, -74.590028
863, -159.52788, 26.645054, -80.796231
864, -218.43645, 33.333375, -118.74213
865, -276.96317, 18.629648, -0.34073624
866, 1046.8981, 32.309944, -15.319813
867, 1010.8421, 27.661577, -24.00684
868, 1053.1532, 29.764413, 26.311729
869, -22.052483, 30.195386, -156.5008
870, -73.64183, 30.916096, -134.82823
871, -132.97084, 31.619961, -101.5175
872, -68.577908, 29.216737, -185.79888
873, 49.934576, 20.012428, -198.69388
874, 68.002947, 24.88272, -162.01049
875, 21.187253, 33.906045, -153.7187
876, 48.06294, 20.265922, -222.94353
877, 108.52544, 29.195205, -246.29469
878, 12.145107, 20.810039, -177.798
879, 70.900563, 30.864643, -222.83083
880, 46.372153, 41.139721, -209.72138
881, 41.424631, 18.535775, -245.4319
882, 14.09004, 17.582088, -271.48476
883, -6.5866156, 18.218721, -271.2457
884, -167.26834, 17.714442, -3.5798924
885, -186.53063, 16.081424, -5.6339487
886, -183.74738, 19.560449, 14.604249
887, 33.734419, 19.121678, 186.56323
888, -197.67825, 18.274209, 47.431405
889, -216.65626, 17.750633, 45.121458
890, -34.457429, 19.946204, -188.43374
891, 43.339936, 40.107153, 199.89656
892, 38.371814, 17.068901, 208.8092
893, 48.92353, 20.815323, 226.01246
894, 44.126667, 39.282281, 219.20669
895, 45.780891, 39.686112, 239.78314
896, 32.394116, 40.686781, 182.72407
897, -52.746497, 29.441903, -256.85933
898, -55.413235, 28.616067, -217.80908
899, -50.007588, 22.701604, -166.94881
900, -131.07902, 29.064959, 204.92438
901, -108.1399, 32.246215, -170.00029
902, 44.344837, 40.508813, -239.7765
903, -4.1899631, 40.960752, -272.50262
904, 31.027647, 34.747532, -269.83191
905, 95.732605, 39.268364, -211.83724
906, 72.604562, 33.977823, -195.37209
907, 54.405526, 39.911528, -178.20207
908, -38.240655, 29.617322, 264.66254
909, 66.641216, 30.374723, -255.4014
910, -26.60948, 28.51026, -271.37276
911, -31.773739, 42.017496, -187.94372
912, 33.225594, 20.479449, -181.53007
913, 32.749901, 41.959381, -187.12572
914, 14.238478, 45.528842, -189.57367
915, -2.3473716, 39.799083, -180.7899
916, -13.674646, 20.868272, -180.56476
917, -162.41316, 17.879803, -109.02414
918, -171.93751, 41.046278, -110.6001
919, -273.25154, 43.54672, -3.2972233
920, -268.55451, 25.715549, -24.966033
921, -181.65437, 36.981834, -8.8972908
922, -186.10398, 41.330013, 11.070866
923, -189.45055, 37.023114, 34.385566
924, -209.10074, 39.135612, 52.39079
925, -270.58487, 33.47777, 22.384694
926, -246.76006, 39.486026, 39.190564
927, -235.03349, 30.796634, 64.557967
928, -204.97537, 24.408847, 75.234854
929, -187.89023, 23.645207, -29.790096
930, -167.2129, 27.043577, 213.85379
931, -116.78288, 24.041436, 137.93098
932, 42.301992, 17.348797, 245.89823
933, -6.0708401, 19.842593, 179.84844
934, 13.484457, 37.821537, 181.58359
935, -56.216977, 32.442231, 197.78795
936, -34.127176, 24.656826, 187.74203
937, -20.544372, 41.217222, 180.4572
938, 42.987379, 29.961498, 266.82394
939, -2.9557403, 40.975105, 181.93425
940, -1.2417348, 42.017044, 163.62746
941, -190.39063, 23.148275, -111.09712
942, -116.90524, 118.84393, -28.591405
943, 20, 330, -148.6607
944, 58.303383, 360, -137.73417
945, 123.41572, 360, -83.354153
946, 149.14625, 360, 7.0949796
947, 119.15011, 360, 89.605596
948, 57.931696, 360, 137.93386
949, -8.8817842e-15, 300, -149.851
950, -20, 330, -148.6607
951, -57.656267, 360, -138.08183
952, -120.35558, 360, -87.838924
953, -149.54506, 360, -3.780691
954, -121.53839, 360, 86.105466
955, -56.150412, 360, 138.89084
956, 20, 300, -121.27713
957, 4.4408921e-15, 300, -95.76519
958, -20, 300, -121.27713
959, 8.8817842e-15, 300, 149.851
960, -20, 300, 121.27713
961, -4.4408921e-15, 300, 95.76519
962, 20, 300, 121.27713
963, 20, 330, 148.6607
964, 20, 360, 121.27713
965, 20, 330, 93.89356
966, 20, 360, -121.27713
967, 20, 330, -93.89356
968, -20, 360, 121.27713
969, -50.419878, 360, 80.854568
970, -91.320213, 360, 28.456634
971, -87.207297, 360, -37.964394
972, -46.675167, 360, -83.517497
973, -20, 360, -121.27713
974, 47.942535, 360, 82.616249
975, 88.736974, 360, 34.428264
976, 89.740938, 360, -32.107418
977, 49.050705, 360, -81.828211
978, -20, 330, -93.89356
979, -20, 330, 93.89356
980, 461.76246, 0, -50.538453
981, 451.94423, 0, 16.012098
982, 479.62747, 0, 78.776119
983, 537.99023, 0, 114.80051
984, 604.61241, 0, 114.159
985, 660.79547, 0, 78.163394
986, 688.01659, 0, 16.334746
987, 678.27437, 0, -50.44134
988, 634.45141, 0, -100.70856
989, 570.37462, 0, -119.1251
990, 506.21199, 0, -101.05674
991, 318.02408, 0, -236.68952
992, 441.82793, 0, -213.32452
993, 553.44475, 0, -196.88528
994, 647.98761, 0, -183.72224
995, 749.13629, 0, -173.20261
996, 843.51266, 0, -164.32075
997, 923.15409, 0, -159.36245
998, 1000.1182, 0, -154.57083
999, 1072.4165, 0, -152.64465
1000, 1150.8314, 0, -151.0192
1001, 1231.8502, 0, -146.41134
1002, 1292.842, 0, -117.70259
1003, 1334.3988, 0, -66.270144
1004, 1349.9679, 0, 0.28476693
1005, 1335.2618, 0, 64.748814
1006, 1296.8634, 0, 113.93442
1007, 1241.2902, 0, 143.47065
1008, 1168.9748, 0, 150.64311
1009, 1091.6889, 0, 152.24515
1010, 1007.256, 0, 154.12645
1011, 922.331, 0, 159.41369
1012, 843.41298, 0, 164.32696
1013, 750.35749, 0, 173.0756
1014, 649.08749, 0, 183.60785
1015, 553.82175, 0, 196.8302
1016, 446.75269, 0, 212.47381
1017, 322.70355, 0, 235.80638
1018, 214.48632, 0, 258.13814
1019, 140.28159, 0, 275.35498
1020, 87.515998, 0, 287.59755
1021, 44.535537, 0, 295.88805
1022, 6.3126701, 0, 299.07166
1023, -31.594318, 0, 297.55598
1024, -74.924654, 0, 289.73251
1025, -123.25563, 0, 272.57826
1026, -164.83071, 0, 249.62933
1027, -196.2027, 0, 225.89899
1028, -223.52717, 0, 199.26608
1029, -248.9515, 0, 166.81145
1030, -273.04849, 0, 122.88336
1031, -290.15954, 0, 72.959803
1032, -297.72496, 0, 29.95154
1033, -299.50824, 0, -6.4741255
1034, -296.80805, 0, -42.022861
1035, -288.3221, 0, -80.898846
1036, -272.2752, 0, -124.82471
1037, -249.27263, 0, -166.26424
1038, -223.18568, 0, -199.68637
1039, -195.15721, 0, -226.8476
1040, -158.73636, 0, -253.66787
1041, -113.91201, 0, -276.90427
1042, -70.69492, 0, -290.95786
1043, -32.504703, 0, -297.43663
1044, 3.0038633, 0, -299.14206
1045, 40.578531, 0, -296.57911
1046, 85.792565, 0, -287.99742
1047, 141.9958, 0, -274.95725
1048, 215.6679, 0, -257.86399
1049, -173.83457, 0, 188.17914
1050, -153.7519, 0, 189.73475
1051, -137.29174, 0, 178.36963
1052, -131.64179, 0, 159.10139
1053, -139.88117, 0, 140.19557
1054, -158.65674, 0, 131.73024
1055, -177.99267, 0, 137.03987
1056, -189.6463, 0, 153.30724
1057, -188.30508, 0, 173.64609
1058, 858.49085, 0, 79.388247
1059, 907.40307, 0, 89.025366
1060, 951.1799, 0, 73.200282
1061, 981.22258, 0, 37.080668
1062, 989.00479, 0, -7.5592763
1063, 974.56206, 0, -49.405208
1064, 942.6428, 0, -78.918672
1065, 900.24109, 0, -89.96826
1066, 856.01827, 0, -78.364072
1067, 822.99015, 0, -46.21519
1068, 810.35232, 0, -2.6761518
1069, 821.34057, 0, 43.268684
1070, -21.267563, 0, 248.24117
1071, -5.3336762, 0, 257.2478
1072, 12.900342, 0, 254.25013
1073, 26.179171, 0, 242.08224
1074, 29.132948, 0, 224.2012
1075, 21.141875, 0, 207.60122
1076, 5.2191826, 0, 198.7522
1077, -12.648115, 0, 201.6284
1078, -25.888253, 0, 213.55297
1079, -29.193861, 0, 231.53193
1080, -244.33771, 0, 24.38048
1081, -227.49898, 0, 29.885646
1082, -210.78576, 0, 23.681467
1083, -199.82547, 0, 8.9043011
1084, -200.19044, 0, -9.6621567
1085, -211.07859, 0, -23.914997
1086, -228.22808, 0, -29.947943
1087, -245.94386, 0, -23.099612
1088, -256.53894, 0, -8.1475796
1089, -255.6476, 0, 9.9984774
1090, 1114.584, 0, 53.860275
1091, 1160.1048, 0, 60
1092, 1205.4371, 0, 59.284182
1093, 1239.9035, 0, 44.362052
1094, 1258.0435, 0, 14.86439
1095, 1257.1337, 0, -17.51434
1096, 1238.6193, 0, -45.347492
1097, 1205.5557, 0, -59.268573
1098, 1163.1507, 0, -60
1099, 1120.9043, 0, -56.478195
1100, 1092.2059, 0, -35.431202
1101, 1080.4675, 0, -3.5517687
1102, 1087.7151, 0, 29.220537
1103, -63.809132, 0, 71.007664
1104, -15.515057, 0, 93.957405
1105, 31.152105, 0, 90.117067
1106, 70.702626, 0, 64.206665
1107, 94.180485, 0, 13.820595
1108, 82.647697, 0, -48.639549
1109, 35.04596, 0, -88.504179
1110, -17.611176, 0, -93.681445
1111, -60.047031, 0, -73.894426
1112, -89.698285, 0, -32.163133
1113, -93.059175, 0, 22.337791
1114, -173.87643, 0, -134.28952
1115, -153.90014, 0, -132.67643
1116, -137.43167, 0, -143.86156
1117, -131.573, 0, -162.99336
1118, -139.44037, 0, -181.58531
1119, -157.55738, 0, -190.49171
1120, -177.44814, 0, -185.76462
1121, -189.67579, 0, -168.98514
1122, -188.15114, 0, -148.56414
1123, -21.456486, 0, -207.99573
1124, -6.0983818, 0, -198.7522
1125, 11.987296, 0, -201.31017
1126, 25.724934, 0, -213.34817
1127, 29.32393, 0, -230.96206
1128, 21.6473, 0, -247.765
1129, 5.8690143, 0, -257.2478
1130, -11.955466, 0, -254.70516
1131, -25.877464, 0, -242.46056
1132, -29.142492, 0, -224.24301
1133, -85.340726, 60, 286.71498
1134, -133.67681, 60, 267.75335
1135, -173.23976, 60, 244.05692
1136, -203.01741, 60, 219.71571
1137, -229.53402, 60, 191.87301
1138, -255.17794, 60, 156.2014
1139, -278.67864, 60, 108.74889
1140, -293.23943, 60, 59.652546
1141, -298.56405, 60, 18.904685
1142, -298.71264, 60, -16.948484
1143, -294.74794, 60, -53.134705
1144, -284.31965, 60, -94.587134
1145, -265.12156, 60, -139.2572
1146, -241.0297, 60, -177.72442
1147, -214.3975, 60, -209.39006
1148, -184.45337, 60, -236.55965
1149, -145.34244, 60, -262.35227
1150, -98.258508, 60, -282.9727
1151, -55.930912, 60, -294.36555
1152, -19.062096, 60, -299.19891
1153, 16.863666, 60, -298.84719
1154, 56.625049, 60, -293.77672
1155, 107.11305, 60, -283.05068
1156, 169.25552, 60, -268.6325
1157, 243.79992, 60, -251.33685
1158, 339.76952, 60, -232.58559
1159, 455.07166, 60, -211.25835
1160, 563.30031, 60, -195.44531
1161, 659.94081, 60, -182.47909
1162, 762.11972, 60, -171.85231
1163, 854.92087, 60, -163.6105
1164, 933.90963, 60, -158.69283
1165, 1011.2208, 60, -153.91316
1166, 1084.2648, 60, -152.39905
1167, 1165.341, 60, -150.71844
1168, 1244.6758, 60, -142.28599
1169, 1301.3489, 60, -109.44906
1170, 1339.1182, 60, -53.727811
1171, 1348.7686, 60, 10.928336
1172, 1331.4422, 60, 70.975673
1173, 1291.4742, 60, 118.56206
1174, 1236.9521, 60, 144.9886
1175, 1168.7357, 60, 150.64807
1176, 1091.7012, 60, 152.2449
1177, 1005.6318, 60, 154.22756
1178, 920.05358, 60, 159.55548
1179, 840.02916, 60, 164.53762
1180, 745.34715, 60, 173.59669
1181, 643.34566, 60, 184.20501
1182, 547.84023, 60, 197.70415
1183, 439.59424, 60, 213.74607
1184, 310.82415, 60, 238.04834
1185, 200.73165, 60, 261.32947
1186, 130.2879, 60, 277.67369
1187, 79.220053, 60, 289.52236
1188, 36.820869, 60, 297.23535
1189, -0.83184016, 60, 299.22366
1190, -40.099259, 60, 296.44102
1191, 656.1189, 60, 82.854767
1192, 598.14473, 60, 115.75316
1193, 531.52255, 60, 113.20635
1194, 475.84345, 60, 73.294014
1195, 451.1413, 60, 9.3994176
1196, 464.35287, 60, -56.647005
1197, 512.11024, 60, -104.15237
1198, 577.03587, 60, -119.1251
1199, 640.01221, 60, -97.124052
1200, 680.63649, 60, -44.212964
1201, 687.21366, 60, 22.947427
1202, -181.29973, 60, 183.19107
1203, -190.46647, 60, 165.01009
1204, -185.96943, 60, 145.29898
1205, -170.13722, 60, 132.99405
1206, -149.85102, 60, 133.48188
1207, -134.89316, 60, 147.66075
1208, -132.55044, 60, 167.90712
1209, -143.4084, 60, 184.70618
1210, -162.55766, 60, 190.95428
1211, 835.29988, 60, 62.257515
1212, 812.44237, 60, 18.551517
1213, 814.53459, 60, -26.837517
1214, 837.59724, 60, -64.588672
1215, 879.50953, 60, -87.302373
1216, 925.0307, 60, -86.213833
1217, 962.75016, 60, -64.322104
1218, 985.35575, 60, -27.102264
1219, 987.61659, 60, 18.103629
1220, 965.99286, 60, 60.572792
1221, 928.40653, 60, 84.815522
1222, 880.39346, 60, 87.418745
1223, -24.653946, 60, 243.9948
1224, -29.562108, 60, 226.08147
1225, -22.402544, 60, 209.18204
1226, -7.4833555, 60, 199.14118
1227, 10.528175, 60, 200.60749
1228, 24.537575, 60, 211.85928
1229, 29.679783, 60, 229.40296
1230, 22.674076, 60, 246.47747
1231, 7.7355831, 60, 256.73735
1232, -10.360025, 60, 255.47349
1233, -248.06073, 60, 21.411464
1234, -257.2478, 60, 5.6017932
1235, -254.43233, 60, -12.522
1236, -242.14789, 60, -26.126812
1237, -223.63405, 60, -29.003501
1238, -207.39448, 60, -20.977001
1239, -198.7522, 60, -5.1351833
1240, -201.93209, 60, 13.278722
1241, -214.58173, 60, 26.708668
1242, -232.23249, 60, 29.033962
1243, 1096.6577, 60, 41.232438
1244, 1081.4499, 60, 11.015497
1245, 1084.9072, 60, -22.441666
1246, 1106.7458, 60, -49.464374
1247, 1144.8058, 60, -60
1248, 1187.8009, 60, -60
1249, 1225.9063, 60, -53.657161
1250, 1251.7724, 60, -30.247069
1251, 1259.7611, 60, 1.8149236
1252, 1249.66, 60, 32.999785
1253, 1221.421, 60, 55.515012
1254, 1180.0057, 60, 60
1255, 1133.1578, 60, 59.099198
1256, -109.70961, 60, 101.08856
1257, -136.29125, 60, 61.807642
1258, -147.64491, 60, 20.902063
1259, -148.36742, 60, -14.489612
1260, -140.56427, 60, -49.596108
1261, -121.50792, 60, -86.786337
1262, -89.236978, 60, -119.96808
1263, -48.01536, 60, -141.11739
1264, -7.5832655, 60, -149.14557
1265, 28.256144, 60, -146.81631
1266, 71.901765, 60, -130.86051
1267, 123.23908, 60, -84.031214
1268, 149.45363, 60, -4.8491613
1269, 128.04605, 60, 76.380958
1270, 80.618251, 60, 125.38358
1271, 38.448548, 60, 144.46498
1272, 2.1910886, 60, 149.75312
1273, -37.303215, 60, 144.86575
1274, -76.667939, 60, 127.86573
1275, -181.25787, 60, -139.22158
1276, -190.39277, 60, -157.05998
1277, -186.10934, 60, -176.93223
1278, -169.59371, 60, -189.55474
1279, -148.98582, 60, -188.43291
1280, -134.50831, 60, -174.20388
1281, -132.59959, 60, -154.28641
1282, -143.53407, 60, -137.65048
1283, -162.60709, 60, -131.49616
1284, -24.219089, 60, -211.45991
1285, -29.87155, 60, -228.56278
1286, -23.194222, 60, -245.82523
1287, -8.078078, 60, -256.57241
1288, 10.001552, 60, -255.64612
1289, 24.451833, 60, -244.24824
1290, 29.669346, 60, -226.55131
1291, 23.041692, 60, -209.98351
1292, 8.1099081, 60, -199.44291
1293, -10.231694, 60, -200.46471
1294, -20, 330, 148.6607
1295, 424.14963, 0, -40.878329
1296, 438.16949, 0, -71.857667
1297, 419.58469, 0, 42.309543
1298, 415.17385, 0, 9.2893649
1299, 467.91191, 0, 112.38821
1300, 444.85872, 0, 85.847607
1301, 617.98581, 0, 145.12291
1302, 586.0027, 0, 154.55556
1303, 460.02519, 0, -109.84985
1304, 488.46216, 0, -127.34719
1305, 699.98474, 0, 74.457084
1306, 678.32957, 0, 99.81778
1307, 708.91966, 0, 2.4255723
1308, 704.33019, 0, 36.271566
1309, 698.36046, 0, -77.616418
1310, 712.13488, 0, -47.214145
1311, 568.6704, 0, -152.30526
1312, 601.98149, 0, -152.2156
1313, 343.75759, 0, -180.48019
1314, 284.30061, 0, -191.70127
1315, 649.76473, 0, -146.56705
1316, 881.08151, 0, -124.39744
1317, 839.95447, 0, -127.34893
1318, 919.56357, 0, -122.00163
1319, 1020.6253, 0, -121.2168
1320, 982.11897, 0, -123.02782
1321, 1167.6041, 0, -105.02906
1322, 1122.9568, 0, -105.95454
1323, 1245.0621, 0, -94.449269
1324, 1209.6475, 0, -102.3083
1325, 1269.4651, 0, -75.103726
1326, 1269.4231, 0, 100.37219
1327, 1292.2292, 0, 81.364834
1328, 1157.777, 0, 105.72961
1329, 1197.1221, 0, 104.53272
1330, 906.97903, 0, 122.95989
1331, 945.4611, 0, 120.56408
1332, 709.51406, 0, 138.96519
1333, 762.1961, 0, 133.48617
1334, 539.1593, 0, 161.39974
1335, 407.84371, 0, 173.47798
1336, 467.86756, 0, 163.47264
1337, 184.28136, 0, 226.92754
1338, 228.27229, 0, 216.72085
1339, 72.19378, 0, 271.9962
1340, 94.795559, 0, 267.00985
1341, -83.590106, 0, 269.17463
1342, -60.458017, 0, 275.10097
1343, -163.02767, 0, 225.73417
1344, -146.25337, 0, 236.84998
1345, -187.20394, 0, 201.80152
1346, -172.75003, 0, 214.60089
1347, -213.11517, 0, 174.01884
1348, -200.64478, 0, 188.18257
1349, -257.91344, 0, 105.65521
1350, -246.37526, 0, 130.90223
1351, -279.36234, 0, -47.031119
1352, -281.79998, 0, -29.422927
1353, -245.75173, 0, -127.34415
1354, -256.12594, 0, -104.83727
1355, -197.25167, 0, -196.19043
1356, -210.3817, 0, -181.3897
1357, -99.069161, 0, -258.72661
1358, -121.7295, 0, -249.46567
1359, 47.025701, 0, -280.519
1360, 27.333184, 0, -283.32517
1361, 148.71756, 0, -245.03621
1362, 117.94466, 0, -252.17608
1363, -144.49625, 0, 199.20928
1364, -154.17268, 0, 201.82154
1365, -127.53719, 0, 179.27094
1366, -133.40003, 0, 187.38056
1367, -122.12643, 0, 153.93196
1368, -121.56132, 0, 164.01558
1369, -135.47708, 0, 126.37998
1370, -128.10027, 0, 133.81933
1371, -164.73096, 0, 121.87189
1372, -154.68119, 0, 122.60716
1373, -188.22103, 0, 133.53731
1374, -180.01501, 0, 127.81872
1375, -202.43816, 0, 155.28205
1376, -199.65574, 0, 145.63947
1377, 1002.7623, 0, 31.714258
1378, 993.02851, 0, 53.066035
1379, 1004.3356, 0, -14.789052
1380, 1006.126, 0, 6.9859238
1381, 981.21756, 0, -77.824626
1382, 993.56064, 0, -59.105083
1383, 808.61224, 0, 66.623411
1384, 796.72078, 0, 44.592519
1385, 802.66082, 0, -40.274538
1386, 814.55231, 0, -60.115084
1387, 793.77926, 0, 6.3804735
1388, 794.33968, 0, -15.817746
1389, -23.859621, 0, 259.41539
1390, -30.332885, 0, 253.08323
1391, 0.17338682, 0, 266.15029
1392, -8.9825512, 0, 264.3668
1393, 19.463773, 0, 259.46067
1394, 11.318021, 0, 263.4958
1395, 36.495938, 0, 246.69543
1396, 32.383768, 0, 254.53532
1397, 40.036447, 0, 222.06842
1398, 40.919714, 0, 231.35716
1399, -37.35496, 0, 238.50171
1400, -38.161099, 0, 229.01714
1401, 23.362394, 0, 196.77513
1402, 29.955632, 0, 203.14559
1403, 2.9061029, 0, 189.38868
1404, 11.870198, 0, 191.10225
1405, -25.004682, 0, 196.68189
1406, -16.957736, 0, 192.82916
1407, -36.603374, 0, 215.62678
1408, -32.397659, 0, 207.83194
1409, -245.74494, 0, 34.66322
1410, -253.33089, 0, 29.960834
1411, -223.60872, 0, 37.269698
1412, -232.39273, 0, 37.384053
1413, -204.33271, 0, 29.565478
1414, -211.68111, 0, 34.700599
1415, -191.51108, 0, 7.0625631
1416, -194.14407, 0, 16.124769
1417, -194.07156, 0, -16.45373
1418, -191.29658, 0, -7.6105749
1419, -261.68767, 0, 18.497353
1420, -264.58412, 0, 9.4952796
1421, -210.78336, 0, -35.699559
1422, -203.53084, 0, -30.848762
1423, -230.73856, 0, -38.321877
1424, -221.31768, 0, -38.373934
1425, -259.03575, 0, -25.431295
1426, -251.54539, 0, -31.197524
1427, -265.87626, 0, -3.9683119
1428, -263.5672, 0, -12.451199
1429, 1104.7597, 0, 71.938371
1430, 1086.3921, 0, 63.52619
1431, 1259.2831, 0, 50.059471
1432, 1245.4041, 0, 62.226489
1433, 1277.8245, 0, 11.803528
1434, 1273.8805, 0, 27.51485
1435, 1271.5677, 0, -28.633245
1436, 1276.3799, 0, -13.171852
1437, 1077.4432, 0, 37.450909
1438, 1069.568, 0, 23.165534
1439, 1068.0025, 0, -35.910902
1440, 1077.9781, 0, -49.330015
1441, 1069.676, 0, 3.9753387
1442, 1070.8341, 0, -13.247057
1443, -80.383676, 0, 102.81464
1444, -102.69614, 0, 83.280704
1445, -4.1266746, 0, 112.02576
1446, -27.62487, 0, 108.1181
1447, 46.037948, 0, 103.51786
1448, 24.258752, 0, 110.94074
1449, 92.987797, 0, 68.697012
1450, 76.640931, 0, 86.64297
1451, 123.43188, 0, 3.0355103
1452, 118.97871, 0, 34.066147
1453, -108.14671, 0, 33.855395
1454, -114.24719, 0, 7.3465577
1455, 96.498659, 0, -79.549977
1456, 112.79081, 0, -51.948136
1457, 31.319987, 0, -109.94045
1458, 59.061908, 0, -98.867015
1459, -31.107706, 0, -105.14186
1460, -8.4667685, 0, -109.48859
1461, -83.401978, 0, -78.017613
1462, -64.96761, 0, -93.02877
1463, -114.58732, 0, -26.6582
1464, -105.20632, 0, -52.424617
1465, -174.62787, 0, -123.28315
1466, -183.8477, 0, -127.40069
1467, -148.10176, 0, -126.0853
1468, -157.74382, 0, -123.53883
1469, -126.78878, 0, -141.92709
1470, -132.70591, 0, -133.90973
1471, -122.75413, 0, -168.74214
1472, -122.33046, 0, -158.67785
1473, -197.17087, 0, -141.19129
1474, -201.28842, 0, -150.4111
1475, -136.5937, 0, -190.66807
1476, -129.59711, 0, -183.38999
1477, -157.82075, 0, -203.10794
1478, -147.7976, 0, -201.94062
1479, -22.944006, 0, -198.16871
1480, -29.144269, 0, -204.3694
1481, -4.3119953, 0, -191.70895
1482, -13.279236, 0, -193.62392
1483, 19.445825, 0, -196.0235
1484, 11.18236, 0, -192.4197
1485, 33.698142, 0, -216.00065
1486, 29.281336, 0, -207.90182
1487, 36.671355, 0, -232.81162
1488, 37.347425, 0, -224.00702
1489, -39.230942, 0, -218.55067
1490, -40.08845, 0, -227.81018
1491, 23.932975, 0, -260.79798
1492, 30.577653, 0, -253.82704
1493, 1.551922, 0, -266.71065
1494, 10.111797, 0, -264.94102
1495, -19.684346, 0, -261.48705
1496, -11.271493, 0, -265.14577
1497, -34.258055, 0, -246.94231
1498, -29.846249, 0, -255.15623
1499, 678.05077, 0, -128.85106
1500, 964.42286, 0, 93.041252
1501, 979.77482, 0, 129.49505
1502, 1026.255, 0, 127.50166
1503, 983.6847, 0, 79.552282
1504, 507.0227, 0, 152.58994
1505, 716.16432, 0, -127.50935
1506, 387.18449, 0, -13.972919
1507, 403.48275, 0, 79.73284
1508, 666.49096, 0, 139.40721
1509, 725.69812, 0, 61.190246
1510, 733.25879, 0, -26.634989
1511, 844.00054, 0, -93.881674
1512, 806.46402, 0, -134.19398
1513, 1036.9734, 0, 93.299098
1514, 1064.4918, 0, 118.82853
1515, 248.70018, 0, -154.14397
1516, 222.96668, 0, -210.3533
1517, 1008.0804, 0, 75.485978
1518, 473.23651, 0, -171.92722
1519, 408.67636, 0, -182.79671
1520, 521.82699, 0, -159.14944
1521, 769.44598, 0, -121.96797
1522, 1045.2569, 0, -102.28864
1523, 1027.2334, 0, -70.160835
1524, 1079.0246, 0, -101.58868
1525, 1319.6044, 0, -29.045651
1526, 1304.0277, 0, -60.32351
1527, 1320.9817, 0, 29.33533
1528, 1321.049, 0, -4.0702703
1529, 1306.8267, 0, 58.820214
1530, 1207.8766, 0, 76.944451
1531, 1219.049, 0, 121.47717
1532, 1251.0068, 0, 112.27786
1533, 1102.4073, 0, 118.04259
1534, 819.28865, 0, 140.97879
1535, 859.69335, 0, 138.08524
1536, 348.89526, 0, 184.07469
1537, 369.80834, 0, 133.86761
1538, 344.5343, 0, 90.329549
1539, 284.66857, 0, 196.19788
1540, 118.49106, 0, 258.08346
1541, 148.70487, 0, 251.07331
1542, 180.06748, 0, -220.30669
1543, 34.190458, 0, 279.29281
1544, 54.555462, 0, 276.11546
1545, -7.695718, 0, 287.2518
1546, 10.125828, 0, 286.87265
1547, -42.638219, 0, 280.03903
1548, -22.572788, 0, 282.30039
1549, -128.08012, 0, 245.20124
1550, -103.00388, 0, 256.36638
1551, -223.28992, 0, 130.69714
1552, -237.18494, 0, 147.31882
1553, -224.77661, 0, 165.85051
1554, -270.28583, 0, 62.435925
1555, -264.05202, 0, 86.687172
1556, -285.53105, 0, 14.795129
1557, -283.86736, 0, 33.408688
1558, -286.33143, 0, -16.442831
1559, -286.82319, 0, 1.3315375
1560, -264.94385, 0, -82.926294
1561, -270.85025, 0, -61.78822
1562, -223.79986, 0, -163.33502
1563, -236.31494, 0, -144.56513
1564, -174.11549, 0, -214.59277
1565, -188.59684, 0, -201.90752
1566, -60.169117, 0, -278.41484
1567, -80.509328, 0, -273.41314
1568, -17.132945, 0, -286.28248
1569, -34.813629, 0, -284.08167
1570, 13.512006, 0, -287.4682
1571, -4.3095301, 0, -287.84735
1572, 89.680221, 0, -262.71008
1573, 64.17399, 0, -268.2368
1574, -133.35411, 0, 201.1261
1575, -116.28203, 0, 174.04202
1576, -116.28, 0, 138.67403
1577, -141.45796, 0, 114.78859
1578, -175.94613, 0, 116.96259
1579, -202.66489, 0, 135.01157
1580, 374.95289, 0, -137.80846
1581, 859.86817, 0, 101.14034
1582, 835.94908, 0, 89.000298
1583, 884.02376, 0, 124.8646
1584, 61.885018, 0, 255.77384
1585, -126.27708, 0, 221.30607
1586, -51.456498, 0, 260.2119
1587, 162.49084, 0, 209.65602
1588, 156.01633, 0, -197.52551
1589, -88.690068, 0, 242.46559
1590, -238.61881, 0, 95.312524
1591, -256.92972, 0, -49.354461
1592, -221.34503, 0, -125.15449
1593, -88.719026, 0, -247.02355
1594, 50.989257, 0, -255.60524
1595, -164.17397, 0, -227.78168
1596, 1020.7879, 0, 24.271397
1597, 1018.1923, 0, -40.176919
1598, 777.92255, 0, 31.395166
1599, 801.0667, 0, -78.228592
1600, 823.99569, 0, -82.613213
1601, 783.30217, 0, -31.273671
1602, -40.658775, 0, 250.56844
1603, -18.759629, 0, 270.10137
1604, 31.326704, 0, 264.81846
1605, 48.670476, 0, 244.55484
1606, -46.123125, 0, 222.59657
1607, 21.440427, 0, 185.69803
1608, -37.172423, 0, 198.05616
1609, -241.85468, 0, 43.937811
1610, -216.57486, 0, 44.089543
1611, -273.21258, 0, 4.8264239
1612, 1238.1059, 15.751461, 45.741431
1613, 1231.6558, 30, 50.690935
1614, 1243.7916, 45.751461, 40.64688
1615, -213.29385, 0, -46.171691
1616, -243.0333, 0, -45.954625
1617, -269.97326, 0, -21.617264
1618, 1131.9567, 0, 105.35499
1619, 1226.9879, 0, 74.132158
1620, 1294.3862, 0, 0.012942002
1621, 1057.4203, 0, 13.285213
1622, 1054.6967, 0, -28.568827
1623, 11.649195, 0, 128.08329
1624, 70.637604, 0, 110.12337
1625, 127.2315, 0, 58.617614
1626, -133.4951, 0, -14.293967
1627, 142.58134, 0, -30.996898
1628, 94.503515, 0, -105.29758
1629, 17.28001, 0, -124.16276
1630, -56.36665, 0, -111.59781
1631, -112.03089, 0, -73.891721
1632, -198.58507, 0, -128.58488
1633, -168.37785, 0, -115.04997
1634, -136.09796, 0, -123.13007
1635, -116.2438, 0, -147.70527
1636, -118.62846, 0, -179.10389
1637, -136.67534, 0, -205.02429
1638, -21.594698, 0, -189.2105
1639, 42.379088, 0, -217.85022
1640, -6.6248017, 0, -274.60862
1641, -239.59973, 0, -86.022536
1642, 418.01597, 0, -102.1328
1643, 103.21884, 0, 242.72818
1644, 1191.0265, 0, -105.04686
1645, 1248.2197, 0, 81.983233
1646, 40.919376, 0, 208.41912
1647, 53.977182, 0, 215.56727
1648, 43.896367, 0, 196.64444
1649, -8.5452899, 0, 183.73707
1650, -1.5031617, 0, 174.37355
1651, -21.367, 0, 177.81402
1652, -189.5339, 0, 27.293745
1653, -189.84844, 0, 39.24871
1654, -179.6598, 0, 25.808001
1655, 29.944446, 0, -197.10118
1656, 29.557404, 0, -187.16489
1657, 39.392914, 0, -199.04321
1658, -40.26121, 0, -207.89962
1659, -52.463082, 0, -211.46679
1660, -42.376409, 0, -197.28552
1661, 96.401981, 0, -232.78904
1662, 263.82947, 0, -96.451665
1663, 202.49554, 0, -115.10369
1664, 1046.3172, 0, 66.812851
1665, 960.73475, 0, -111.76345
1666, 1105.1376, 0, -99.686021
1667, 1281.2334, 0, 47.532943
1668, -211.85521, 0, 118.59498
1669, 126.65006, 0, 208.13327
1670, 162.22656, 0, 183.9875
1671, -58.478573, 0, 245.63038
1672, 20.01979, 0, -272.03046
1673, -213.18004, 0, -171.37065
1674, -142.02969, 0, -241.44558
1675, 942.31366, 0, -121.96989
1676, -115.18087, 0, 209.47735
1677, -107.92057, 0, 190.1544
1678, -100.84354, 0, 210.33437
1679, 66.308794, 0, 240.43557
1680, 7.2620748, 0, 272.39829
1681, 1089.8808, 15.389611, -32.401317
1682, 1082.064, 15.389611, -15.577479
1683, -180.65856, 0, -7.4514862
1684, -188.11418, 0, -0.35481047
1685, 1066.2613, 0, 58.550689
1686, 11.69392, 0, -181.00765
1687, 3.817497, 0, -187.34014
1688, -51.682321, 0, -232.15881
1689, -40.337957, 0, -237.85115
1690, 47.725942, 0, -241.54485
1691, 1247.2027, 29.589199, -36.201862
1692, 1248.6303, 45.083077, -34.341584
1693, 1238.9494, 44.506122, -45.094154
1694, 278.80484, 0, 104.87794
1695, 312.47926, 0, 50.743171
1696, 83.457555, 0, 234.25261
1697, 107.15306, 0, 225.32621
1698, 773.49205, 0, -88.500713
1699, 808.20092, 0, 91.984099
1700, -214.26092, 0, 103.74102
1701, -193.6359, 0, 108.05545
1702, 150.64447, 0, -168.88528
1703, 119.29456, 0, -193.6148
1704, -220.3995, 0, 84.772986
1705, -44.975533, 0, -277.75085
1706, -54.965608, 0, -261.04609
1707, -196.47317, 0, 197.67414
1708, -208.02186, 0, -111.3639
1709, -90.004678, 0, 224.70092
1710, -70.590906, 0, 237.50917
1711, -59.793183, 0, 227.86571
1712, -82.74438, 0, 205.37796
1713, -101.9447, 0, 174.89904
1714, -178.35184, 0, 102.10862
1715, -180.87306, 0, 7.2216519
1716, 70.243013, 0, 223.03361
1717, -195.89877, 0, -95.648212
1718, -218.65873, 0, -92.217826
1719, -171.25762, 0, -13.896543
1720, -168.07522, 0, -6.6407781
1721, 21.573855, 0, -172.10156
1722, 14.208992, 0, -167.022
1723, -45.851925, 0, -251.29094
1724, 791.9518, 0, 118.6019
1725, -170.61812, 0, 6.3551882
1726, -174.01502, 0, 13.772562
1727, -263.56367, 0, 29.753497
1728, -58.235458, 0, 214.47536
1729, -52.687999, 0, 199.19312
1730, -45.295022, 0, 188.04307
1731, -236.62993, 0, 61.501566
1732, -249.98214, 0, 58.780734
1733, 20.543899, 0, 171.71567
1734, 32.036095, 0, 177.38854
1735, -208.49602, 0, 53.289035
1736, -220.42364, 0, 55.858135
1737, 1230.8276, 14.506122, -51.326479
1738, 1223.273, 44.506122, -54.747894
1739, 1216.4473, 30, -57.575193
1740, -191.20073, 0, -26.06782
1741, -190.42941, 0, -38.716373
1742, -3.8004358, 0, -180.2969
1743, 1282.6538, 0, -63.994316
1744, 97.81734, 0, 118.38871
1745, 67.214357, 0, 135.26361
1746, 155.07486, 0, 71.154113
1747, 129.08394, 0, 105.78498
1748, 85.49473, 0, -144.79459
1749, 122.93148, 0, -125.47755
1750, 1256.7299, 45.083077, -18.489335
1751, 1259.005, 30.221308, -7.5594163
1752, 1259.5679, 45.138231, -3.2824796
1753, -125.55235, 0, -112.85912
1754, -140.94819, 0, -105.0347
1755, -98.069262, 0, -150.95212
1756, -102.52758, 0, -134.20135
1757, -113.35259, 0, -193.73313
1758, -106.50961, 0, -179.08528
1759, -158.05956, 0, -101.58751
1760, -174.94361, 0, -101.33183
1761, -185.58048, 0, -82.185756
1762, -147.51395, 0, -91.316557
1763, -20.673792, 0, -178.59399
1764, -30.338562, 0, -183.13878
1765, -29.61012, 0, -266.71293
1766, -227.47664, 0, -70.306851
1767, 751.10837, 0, 84.491488
1768, 1037.3683, 0, 40.73757
1769, 50.149099, 0, -208.92509
1770, 50.812209, 0, -198.12445
1771, 27.52026, 30.345981, 217.13555
1772, 28.38721, 37.725775, 220.9339
1773, 25.165728, 37.72746, 212.64695
1774, 106.88878, 0, 199.65769
1775, -169.40486, 0, 24.941538
1776, 254.46361, 0, 164.98729
1777, 21.270463, 0, 284.21816
1778, -275.51059, 0, 44.872169
1779, 353.09719, 0, -99.816276
1780, 45.301183, 0, 179.70021
1781, 56.264927, 0, 184.97375
1782, 44.404655, 0, 165.71785
1783, -127.57905, 0, -224.31693
1784, -95.24468, 0, -169.98616
1785, -81.528467, 0, -156.48224
1786, -89.96881, 0, -184.61541
1787, -161.21717, 0, -0.089868173
1788, -180.59824, 0, 49.963325
1789, -195.39705, 0, 52.235058
1790, -180.97013, 0, -24.32134
1791, -168.38678, 0, -23.510632
1792, -62.657161, 0, -227.91644
1793, -62.906668, 0, -237.95741
1794, -61.04551, 0, -251.95493
1795, -135.58451, 0, 97.017581
1796, -116.0268, 0, 61.736878
1797, -45.327147, 0, 130.97756
1798, -56.215785, 0, 109.92734
1799, -141.03507, 0, 47.592273
1800, -72.020351, 0, -247.71256
1801, 222.40857, 0, 125.40091
1802, -116.37515, 0, -213.04438
1803, -64.94803, 0, -215.51767
1804, -76.172377, 0, -221.31626
1805, -65.978298, 0, -204.86662
1806, -154.78862, 0, 93.24476
1807, -161.9824, 0, 56.225366
1808, -154.1023, 0, 28.343884
1809, 1040.732, 0, 16.009236
1810, 8.626859, 0, 166.06131
1811, 19.222527, 0, 157.75182
1812, -2.8245338, 0, 160.4097
1813, -172.47839, 0, 84.337619
1814, 755.45382, 0, 46.30597
1815, 752.51229, 0, 8.0939241
1816, 344.59905, 0, 2.2020216
1817, 353.57483, 0, -47.965673
1818, -199.24582, 0, 64.003649
1819, 1092.0647, 14.258154, 35.247164
1820, 1097.0005, 44.258154, 41.679115
1821, 1103.787, 30, 47.193965
1822, 1250.2441, 15.751461, 32.238634
1823, 1255.6585, 30.889691, 21.075818
1824, 1256.6088, 15.138231, 18.781678
1825, -90.580184, 0, -233.02603
1826, 32.072475, 0, -173.17924
1827, 1038.0084, 0, -25.844804
1828, 278.86959, 0, 16.750418
1829, 310.51175, 0, -83.641335
1830, -228.55109, 0, 70.701058
1831, -66.358057, 0, 204.46227
1832, -37.083841, 0, 173.6485
1833, -28.671395, 0, 164.55642
1834, -52.599417, 0, 174.78547
1835, 107.50585, 0, -213.12325
1836, 79.241418, 0, -223.65725
1837, -236.1229, 0, -56.478814
1838, -3.5557848, 0, -166.66399
1839, -11.685277, 0, -171.0328
1840, 76.031918, 0, 155.77923
1841, 48.852182, 0, 147.51389
1842, 23.670054, 0, 139.54786
1843, -4.7153725, 0, 140.63289
1844, 125.6607, 0, 130.92521
1845, -145.91462, 0, 3.3124779
1846, -146.25475, 0, -30.69228
1847, 0.79109079, 0, -140.9134
1848, 40.577846, 0, -141.36526
1849, -87.289802, 0, -118.46646
1850, -53.429897, 0, -130.57956
1851, -132.1189, 0, -71.531234
1852, -110.31456, 0, -97.12423
1853, 75.956841, 0, -205.9989
1854, 64.852969, 0, -225.66469
1855, -105.46434, 0, -115.21961
1856, -40.830044, 0, -186.82489
1857, -51.946985, 0, -190.35512
1858, -39.909138, 0, -176.20838
1859, 264.30711, 0, -44.601062
1860, -149.23028, 0, -68.084048
1861, 102.13399, 0, -184.48301
1862, 1081.3056, 29.647764, 9.9193757
1863, 1081.2858, 45.389611, 9.7691149
1864, 1086.9425, 44.258154, 27.355132
1865, 6.3241504, 0, -157.7579
1866, -20.429141, 0, -164.96108
1867, -155.86452, 0, -54.184051
1868, -171.25957, 0, -73.969374
1869, -30.562234, 0, 144.77961
1870, -59.153149, 0, 146.58885
1871, 174.78255, 0, -71.695967
1872, 159.65326, 0, -129.38827
1873, -192.21473, 0, -68.28576
1874, -104.2563, 0, -213.02578
1875, 64.806339, 0, -190.94373
1876, 54.050154, 0, -181.06185
1877, 185.42362, 0, -16.712322
1878, 199.98611, 0, 44.639158
1879, 201.83855, 0, 91.806523
1880, -14.845393, 0, 148.94513
1881, -94.162301, 0, 162.33081
1882, -85.800841, 0, 178.4432
1883, -77.196921, 0, 190.09573
1884, 46.066605, 0, -165.99852
1885, -16.973686, 0, -140.5554
1886, 1040.84, 0, -3.1809596
1887, -35.188243, 0, -137.63804
1888, -29.655183, 0, -154.48254
1889, -66.111395, 0, -144.50669
1890, 1085.8436, 45.389611, -24.702119
1891, 1098.2288, 30, -42.928837
1892, 62.555524, 0, -149.24788
1893, 90.98349, 0, -169.42785
1894, 1084.1869, 14.258154, 20.70254
1895, 1080.2752, 15.389611, 2.0909686
1896, 53.798382, 0, -216.93146
1897, 79.194787, 0, -188.9363
1898, 28.415226, 30.356622, 234.94335
1899, 27.560758, 37.786826, 238.68702
1900, 29.609645, 37.7745, 229.71026
1901, -89.848491, 0, -201.31601
1902, -78.583565, 0, -192.21689
1903, 755.72752, 0, -41.545793
1904, 764.04866, 0, -66.002584
1905, -92.871053, 0, -220.62726
1906, -191.09423, 0, 78.075578
1907, -167.53101, 0, 69.211714
1908, 232.18731, 0, 3.940088
1909, -204.19321, 0, 79.129555
1910, -69.414519, 0, 177.52751
1911, 71.125942, 0, 209.38431
1912, 35.587095, 0, 145.20222
1913, 70.283326, 0, 192.74569
1914, 86.549157, 0, 200.21202
1915, -148.45752, 0, 16.308444
1916, 71.688142, 0, 175.80146
1917, 106.04616, 0, 183.01908
1918, 177.49732, 0, 151.91587
1919, -92.112113, 0, 145.78673
1920, -75.968251, 0, 149.33089
1921, -61.203337, 0, 163.13293
1922, 141.65654, 0, 150.39311
1923, -190.32667, 0, -51.783347
1924, -177.99656, 0, -47.002404
1925, -38.643698, 0, -162.04372
1926, -98.085954, 0, 125.67411
1927, 57.082958, 0, -234.58982
1928, -63.286812, 0, -163.54073
1929, -215.1819, 0, -62.674104
1930, -204.64759, 0, -59.999728
1931, -49.13518, 0, -165.72983
1932, -64.552252, 0, -177.70539
1933, 90.050317, 0, 163.55118
1934, 110.38994, 0, 162.99685
1935, -66.098617, 0, -188.16601
1936, -155.96726, 0, -41.117077
1937, 271.83362, 30, -245.40686
1938, 331.2906, 30, -234.18578
1939, 511.32854, 30, -203.03878
1940, 558.17195, 30, -196.1946
1941, 605.41651, 30, -189.29181
1942, 653.15211, 30, -183.18512
1943, 702.65283, 30, -178.03697
1944, 755.93449, 30, -172.49559
1945, 808.60318, 30, -167.01796
1946, 849.72198, 30, -163.93417
1947, 889.87365, 30, -161.43442
1948, 928.35572, 30, -159.03861
1949, 967.19006, 30, -156.62087
1950, 1005.6842, 30, -154.2243
1951, 1044.2056, 30, -153.22942
1952, 1077.9733, 30, -152.52946
1953, 1112.4756, 30, -151.81427
1954, 1157.1229, 30, -150.88879
1955, 1203.6649, 30, -149.58706
1956, 1240.4788, 30, -143.75455
1957, 1270.7845, 30, -131.56271
1958, 1296.8841, 30, -113.91375
1959, 1347.0338, 30, -26.324003
1960, 1349.1173, 30, 7.8341514
1961, 1333.8435, 30, 67.153987
1962, 1315.5722, 30, 95.22622
1963, 1294.1947, 30, 116.60302
1964, 1241.5085, 30, 143.39425
1965, 1207.3973, 30, 149.16653
1966, 1168.0584, 30, 150.66211
1967, 1130.268, 30, 151.44546
1968, 1092.3525, 30, 152.2314
1969, 1053.1221, 30, 153.04459
1970, 1006.5877, 30, 154.16805
1971, 959.83913, 30, 157.07852
1972, 921.35707, 30, 159.47433
1973, 882.54545, 30, 161.89065
1974, 842.10168, 30, 164.40859
1975, 694.7383, 30, 178.86009
1976, 646.13656, 30, 183.91475
1977, 597.87497, 30, 190.39369
1978, 551.03157, 30, 197.23787
1979, 250.64286, 30, 249.74917
1980, 206.65193, 30, 259.95586
1981, 164.57511, 30, 269.71844
1982, 134.36131, 30, 276.72859
1983, 187.74935, 30, -264.3416
1984, 230.64855, 30, -254.38821
1985, 105.99437, 30, 283.31023
1986, 83.435837, 30, 288.54422
1987, 60.594158, 30, 293.08355
1988, 40.237192, 30, 296.63872
1989, -15.143377, 30, 299.52814
1990, -35.212748, 30, 297.08162
1991, -56.526249, 30, 294.2875
1992, -79.658338, 30, 288.36116
1993, -103.56217, 30, 281.43623
1994, -128.63527, 30, 270.08753
1995, -156.83052, 14.480576, 254.93081
1996, -173.60482, 14.480576, 243.815
1997, -216.71154, 14.028209, 207.29044
1998, -228.83028, 14.028209, 192.73914
1999, -238.50812, 30, 180.82791
2000, -251.42582, 30, 162.59514
2001, -264.04511, 30, 141.09149
2002, -275.81544, 30, 115.93693
2003, -286.20094, 30, 89.864159
2004, -291.90846, 30, 65.403272
2005, -296.75387, 30, 42.736142
2006, -298.17203, 30, 24.065756
2007, -297.6285, 15.698994, -31.221452
2008, -295.71618, 15.698994, -48.951227
2009, -291.93008, 30, -65.309846
2010, -286.9522, 30, -86.817776
2011, -278.39844, 30, -109.45232
2012, -269.05081, 30, -132.56164
2013, -256.74663, 30, -153.52832
2014, -244.95855, 30, -172.8889
2015, -207.37783, 14.526194, -215.75931
2016, -193.08449, 14.526194, -228.72827
2017, -174.10962, 30, -243.48048
2018, -152.32333, 30, -257.91759
2019, -128.60679, 30, -270.10072
2020, -106.2608, 30, -280.44671
2021, -82.70468, 30, -287.47864
2022, -62.476986, 30, -293.33859
2023, -11.377171, 15.058108, -299.44801
2024, 6.4443652, 15.058108, -299.06886
2025, 69.350112, 30, -291.5544
2026, 94.833984, 30, -285.89964
2027, 123.50197, 30, -279.24815
2028, 154.27487, 30, -272.10828
2029, -177.40133, 44.480576, 241.29917
2030, -161.47183, 44.480576, 251.85516
2031, -299.53368, 30, 6.1391717
2032, -231.71776, 30, -189.18531
2033, -43.533418, 30, -295.99081
2034, -4.5235801, 45.058108, -299.3022
2035, -22.494883, 45.058108, -298.74888
2036, 13.483992, 45.058108, -298.9191
2037, 47.481844, 30, -295.3735
2038, 385.95998, 30, -223.86825
2039, 1319.1724, 30, -90.50363
2040, 1336.7537, 30, -60.485342
2041, 800.96634, 30, 167.8122
2042, 503.78701, 30, 204.14066
2043, 20.638272, 30, 298.76689
2044, -299.11665, 30, -11.62952
2045, 450.36628, 30, -211.94584
2046, 1344.8567, 30, 37.328555
2047, -298.587, 45.698994, -18.602479
2048, 1269.0832, 30, 132.63175
2049, 748.28431, 30, 173.29122
2050, 443.59442, 30, 212.99114
2051, 382.95423, 30, 224.43552
2052, 318.7271, 30, 236.55684
2053, 2.8167255, 30, 299.14604
2054, -138.0553, 44.480576, 265.72615
2055, -182.40683, 29.343018, 237.98218
2056, -189.77672, 14.862441, 231.72955
2057, -204.10016, 14.862441, 218.73328
2058, -193.13739, 44.862441, 228.68027
2059, -29.140507, 15.058108, -297.87767
2060, -207.5675, 44.862441, 215.58722
2061, -231.88478, 44.028209, 188.97975
2062, -219.85425, 44.028209, 203.78661
2063, -297.22492, 45.698994, -36.534739
2064, -294.3634, 45.698994, -54.796195
2065, -187.3693, 44.526194, -233.91391
2066, -202.32361, 44.526194, -220.34522
2067, -210.35808, 28.89065, 213.05521
2068, -217.46566, 44.526194, -206.60619
2069, -221.49822, 14.526194, -201.76325
2070, 27.798578, 30, -298.61455
2071, -71.034766, 60, 270.50445
2072, -94.846567, 60, 263.26182
2073, -155.92312, 60, 234.25592
2074, -171.54726, 60, 223.36338
2075, -180.64405, 60, 210.87273
2076, -195.07416, 60, 197.77968
2077, -235.91854, 60, 157.25075
2078, -249.0472, 60, 136.04602
2079, -271.7699, 60, 73.690005
2080, -276.36978, 60, 50.966048
2081, -275.34146, 60, 25.664849
2082, -276.70312, 60, 7.7382647
2083, -285.38692, 60, -44.142843
2084, -282.00008, 60, -62.282716
2085, -270.94377, 60, -80.491878
2086, -263.31853, 60, -103.49628
2087, -262.36655, 60, -71.619781
2088, -233.33522, 60, -156.80152
2089, -220.82144, 60, -173.68862
2090, -203.3724, 60, -189.40163
2091, -189.16186, 60, -203.89752
2092, -103.00858, 60, -261.16243
2093, -79.766802, 60, -269.27941
2094, -26.835356, 60, -274.6212
2095, -8.946704, 60, -275.80498
2096, 45.683959, 60, -277.62307
2097, 67.529868, 60, -273.67593
2098, 144.75295, 60, -243.57385
2099, 178.22743, 60, -235.80717
2100, 219.75932, 60, -219.92169
2101, 260.94439, 60, -210.94034
2102, 195.25675, 60, -194.86304
2103, 312.5207, 60, -197.48689
2104, 367.19007, 60, -187.16935
2105, 288.36495, 60, -165.5241
2106, 529.78804, 60, -159.25583
2107, 577.0326, 60, -152.35304
2108, 722.80543, 60, -135.80182
2109, 775.47412, 60, -130.32419
2110, 835.60028, 60, -122.45095
2111, 875.74371, 60, -119.8189
2112, 919.86849, 60, -119.5965
2113, 958.70284, 60, -117.17875
2114, 1069.836, 60, -129.01268
2115, 1104.3384, 60, -128.29749
2116, 1142.7252, 60, -105.84193
2117, 1189.2629, 60, -104.33283
2118, 1321.1775, 60, -6.8406821
2119, 1319.0676, 60, 23.406275
2120, 1307.0933, 60, 54.323462
2121, 1291.8644, 60, 82.673753
2122, 1268.281, 60, 101.13442
2123, 1282.5801, 60, 36.754966
2124, 1234.2112, 60, 97.135998
2125, 1204.4832, 60, 104.47146
2126, 933.11977, 60, 123.08415
2127, 894.30816, 60, 125.50048
2128, 660.60468, 60, 141.26049
2129, 612.2465, 60, 147.07839
2130, 334.75184, 60, 174.12725
2131, 266.66716, 60, 187.31772
2132, 138.64059, 60, 250.53173
2133, 110.27365, 60, 257.11337
2134, 45.07467, 60, 282.92765
2135, 25.483788, 60, 285.43365
2136, 579.8819, 60, 154.96323
2137, 440.10914, 60, 81.128678
2138, 461.44556, 60, 109.16133
2139, 421.57282, 60, 3.5896549
2140, 424.40114, 60, 36.801984
2141, 716.65473, 60, 42.988804
2142, 722.82672, 60, 9.3349617
2143, 437.31198, 60, -75.999573
2144, 421.20058, 60, -46.117961
2145, 495.67901, 60, -129.59498
2146, 466.50121, 60, -113.50917
2147, 418.64848, 60, -105.5168
2148, 481.94672, 60, -172.68725
2149, 610.34369, 60, -150.66923
2150, 712.37925, 60, -52.907305
2151, 700.09537, 60, -83.874866
2152, -200.6755, 60, 159.98896
2153, -199.43012, 60, 170.15082
2154, -191.16, 60, 139.14203
2155, -196.55294, 60, 147.56563
2156, -165.41972, 60, 122.39387
2157, -174.98588, 60, 125.56047
2158, -163.60401, 60, 201.42735
2159, -153.46087, 60, 201.69337
2160, -140.58109, 60, 126.42596
2161, -149.96058, 60, 122.56479
2162, -123.70408, 60, 150.7433
2163, -128.36774, 60, 141.45457
2164, -125.40207, 60, 177.70589
2165, -123.08889, 60, 167.96998
2166, -143.29353, 60, 193.05329
2167, -135.35336, 60, 186.93685
2168, 805.34876, 60, 64.617349
2169, 822.48657, 60, 82.697971
2170, 783.92432, 60, 12.090405
2171, 788.88957, 60, 35.995937
2172, 796.38324, 60, -40.501655
2173, 790.2675, 60, -20.386134
2174, 868.12098, 60, 119.95705
2175, 1003.279, 60, -22.070873
2176, 997.0947, 60, -42.158008
2177, 1000.4467, 60, 27.474559
2178, 1005.2752, 60, 3.7119617
2179, 982.85296, 60, 76.586196
2180, 998.66882, 60, 59.325534
2181, -37.947929, 60, 244.33958
2182, -33.147944, 60, 252.35315
2183, -40.596994, 60, 222.09855
2184, -41.034886, 60, 231.44486
2185, -23.403366, 60, 198.99848
2186, -29.245831, 60, 205.80643
2187, -5.6261486, 60, 190.04324
2188, -14.296335, 60, 192.22678
2189, 17.8355, 60, 193.03018
2190, 9.1940931, 60, 190.02429
2191, -15.422831, 60, 261.1296
2192, -6.822046, 60, 264.02605
2193, 33.618009, 60, 212.26689
2194, 28.977981, 60, 204.6812
2195, 34.101445, 60, 232.64601
2196, 34.421662, 60, 223.17841
2197, 29.769789, 60, 249.51176
2198, 24.994791, 60, 262.35215
2199, 38.600248, 60, 259.18563
2200, 3.2620563, 60, 265.92211
2201, 12.095782, 60, 263.63735
2202, -261.03803, 60, -21.461776
2203, -264.77402, 60, -13.51726
2204, -243.11696, 60, -33.37352
2205, -251.54713, 60, -28.956344
2206, -217.15592, 60, -35.73434
2207, -226.37485, 60, -36.860567
2208, -237.37918, 60, 36.896078
2209, -228.59517, 60, 37.862116
2210, -194.21391, 60, -23.024157
2211, -200.35494, 60, -29.424075
2212, -188.2848, 60, -1.1638808
2213, -190.00647, 60, -10.247447
2214, 1258.3857, 15.083077, -12.264662
2215, 1259.6185, 15.138231, 2.8986429
2216, -215.15424, 60, 36.9657
2217, -207.12579, 60, 32.972474
2218, 1081.671, 60, 53.548112
2219, 1093.2278, 60, 65.91893
2220, 1067.7235, 60, 10.45298
2221, 1070.769, 60, 27.084872
2222, 1075.0789, 60, -31.395253
2223, 1068.7582, 60, -15.89958
2224, 1103.1137, 60, -59.542366
2225, 1088.2473, 60, -49.351749
2226, 1117.2051, 60, 69.901716
2227, 1140.967, 60, 73.920956
2228, 1242.5622, 60, -63.800059
2229, 1226.6102, 60, -71.360364
2230, 1270.8734, 60, -31.514284
2231, 1262.171, 60, -46.348354
2232, 1275.8407, 60, 11.684184
2233, 1276.3527, 60, -4.1046701
2234, -165.17025, 60, 13.599461
2235, -162.60303, 60, 31.164429
2236, -162.09549, 60, -19.427276
2237, -163.72807, 60, -1.731441
2238, -152.02169, 60, -64.838567
2239, -158.16128, 60, -47.553766
2240, -42.244137, 60, -159.51107
2241, -64.506462, 60, -152.02459
2242, 45.056385, 60, -155.8055
2243, 27.239294, 60, -159.28019
2244, 96.753146, 60, -142.87249
2245, 71.802958, 60, -156.25258
2246, 158.11813, 60, -84.036578
2247, 135.16239, 60, -118.23488
2248, 181.90953, 60, 20.537139
2249, 180.29781, 60, -21.611299
2250, 140.00477, 60, 109.19371
2251, 161.634, 60, 73.327629
2252, 83.149062, 60, 155.52037
2253, 105.2429, 60, 141.22967
2254, 37.4313, 60, 165.48971
2255, 56.683373, 60, 160.47861
2256, 1.171086, 60, 164.83415
2257, 17.811762, 60, 164.58728
2258, -191.58758, 60, -135.04312
2259, -184.25517, 60, -128.10086
2260, -201.96946, 60, -160.22744
2261, -200.63222, 60, -150.34484
2262, -157.86615, 60, -126.02304
2263, -167.24442, 60, -115.52642
2264, -152.40977, 60, -108.04546
2265, -138.48572, 60, -192.39991
2266, -147.8461, 60, -196.46859
2267, -126.08068, 60, -173.85358
2268, -130.32353, 60, -182.98967
2269, -126.10234, 60, -141.32827
2270, -123.70369, 60, -150.99972
2271, -147.77244, 60, -125.74718
2272, -139.83882, 60, -131.78964
2273, -36.166346, 60, -210.07133
2274, -31.521559, 60, -202.73774
2275, -36.31008, 60, -230.61266
2276, -36.43853, 60, -221.26217
2277, 17.439719, 60, -262.58
2278, 9.1273513, 60, -265.3198
2279, 1252.8614, 15.083077, -27.828569
2280, 1244.2152, 14.506122, -40.094908
2281, 30.961017, 60, -248.31159
2282, 42.467864, 60, -246.5028
2283, 45.107818, 60, -259.45848
2284, 40.766623, 60, -223.59181
2285, 41.097277, 60, -232.39641
2286, 24.442305, 60, -203.76036
2287, 29.944023, 60, -210.85439
2288, 5.0218369, 60, -188.92493
2289, 13.959119, 60, -191.32816
2290, -42.206104, 60, -280.18156
2291, -32.153666, 60, -257.94074
2292, 706.41562, 60, 142.56626
2293, 675.21915, 60, 104.66119
2294, 698.64239, 60, 80.866872
2295, 759.96162, 60, 136.99739
2296, 659.79677, 60, -145.06294
2297, 976.79591, 60, -87.936555
2298, 990.83704, 60, -127.03289
2299, 1029.3462, 60, -125.45247
2300, 992.86516, 60, -72.139546
2301, 686.74097, 60, -125.40298
2302, 532.63734, 60, 161.86602
2303, 500.93354, 60, 151.43409
2304, 826.94658, 60, 122.98505
2305, 461.1077, 60, 162.33418
2306, -61.037157, 60, -276.67109
2307, -113.70795, 60, 250.81495
2308, -137.85928, 60, 238.53104
2309, -214.4431, 60, 185.97797
2310, -226.50065, 60, 171.20091
2311, -255.58466, 60, 117.91885
2312, -265.676, 60, 91.728917
2313, -286.11297, 60, -10.950861
2314, -284.82561, 60, -28.877446
2315, -253.67516, 60, -119.54191
2316, -242.39756, 60, -141.11104
2317, -171.513, 60, -198.30411
2318, -181.67411, 60, -217.47443
2319, -66.254059, 60, -256.10942
2320, -165.8879, 60, -229.78774
2321, -148.97738, 60, -239.67008
2322, -125.61883, 60, -252.62641
2323, -136.44337, 60, 218.19313
2324, 7.8573985, 60, -286.3107
2325, 25.789271, 60, -285.49413
2326, 393.88948, 60, -147.54852
2327, 421.1383, 60, -182.64723
2328, 85.83416, 60, -263.55869
2329, 114.50214, 60, -256.9072
2330, -236.81192, 60, 119.30581
2331, 1013.1597, 60, -67.809155
2332, 1049.4199, 60, -101.35091
2333, 1185.2205, 60, 81.024491
2334, 1187.2374, 60, 125.82064
2335, 1228.1103, 60, -116.27526
2336, 1259.8196, 60, -106.3173
2337, 1279.4284, 60, -88.865597
2338, 1303.1254, 60, -66.971122
2339, 1315.6981, 60, -34.250296
2340, 953.3726, 60, 116.43577
2341, 1236.5361, 60, 63.673731
2342, 1149.4532, 60, 126.90269
2343, 1103.6936, 60, 115.65402
2344, 1064.4632, 60, 116.46722
2345, 1035.1483, 60, 115.24905
2346, 988.34556, 60, 117.28958
2347, -241.66687, 60, -105.87458
2348, 400.29877, 60, 172.62369
2349, 95.649756, 60, 240.92512
2350, 87.297057, 60, 268.06709
2351, 210.7489, 60, 223.37387
2352, 168.67208, 60, 233.13645
2353, 64.498627, 60, 272.85406
2354, 12.58478, 60, 286.71885
2355, -5.3792626, 60, 286.91578
2356, 405.91172, 60, 75.734728
2357, 389.83149, 60, -18.299581
2358, -190.55705, 60, 124.32097
2359, -202.5906, 60, 125.66558
2360, -186.41649, 60, 112.08402
2361, 729.1699, 60, -23.141577
2362, 752.95048, 60, -64.507978
2363, 74.918956, 60, -247.53246
2364, -207.31611, 60, 152.90996
2365, -144.33988, 60, 205.27793
2366, -155.38618, 60, 113.49444
2367, -127.71369, 60, 128.69397
2368, -114.88515, 60, 160.94925
2369, -124.22125, 60, 187.40689
2370, 773.51395, 60, 58.832239
2371, 763.39795, 60, -2.2657117
2372, -161.54028, 60, -201.33534
2373, 827.77703, 60, -82.683653
2374, 811.08362, 60, -66.550573
2375, 1019.3854, 60, -12.044782
2376, 1019.6038, 60, 45.589027
2377, -21.955756, 60, 188.10599
2378, 1.9715172, 60, 181.31533
2379, -2.0568706, 60, 272.70036
2380, 27.93424, 60, 192.9474
2381, 39.880373, 60, 215.50994
2382, 20.92624, 60, 273.31123
2383, -254.89353, 60, 26.247426
2384, -248.66152, 60, 32.512747
2385, -262.80935, 60, -30.374392
2386, -220.30093, 60, 45.86667
2387, -182.02484, 60, -19.445815
2388, -193.78088, 60, 34.481476
2389, -194.04667, 60, 22.483697
2390, 1065.5536, 60, 53.4131
2391, 1055.6862, 60, 0.59729939
2392, 1069.8894, 60, -43.711757
2393, 1146.1924, 60, 95.107792
2394, 1162.7492, 60, 81.186836
2395, 1263.9869, 60, -66.433153
2396, -176.75133, 60, 50.497495
2397, -158.65261, 60, 57.669225
2398, -131.84414, 60, 98.43278
2399, -116.72526, 60, 115.47003
2400, -148.28108, 60, 80.101242
2401, -178.09063, 60, -47.572305
2402, -166.30294, 60, -32.203986
2403, -133.98034, 60, -101.08719
2404, -147.94122, 60, -82.151945
2405, -92.681147, 60, -134.89906
2406, -110.86559, 60, -121.12244
2407, -4.2193627, 60, -164.26816
2408, -21.9152, 60, -163.41374
2409, -90.413596, 60, 138.72392
2410, -73.2557, 60, 148.68708
2411, 136.26841, 60, -145.95633
2412, 196.85733, 60, -58.893437
2413, 198.76148, 60, 56.322332
2414, 143.72409, 60, 141.14879
2415, 82.496526, 60, 178.143
2416, 36.411298, 60, 182.19881
2417, -178.79879, 60, -110.12328
2418, -53.15786, 60, 155.06765
2419, -30.778815, 60, 160.65311
2420, -204.85419, 60, -137.99945
2421, 784.44152, 60, -60.791168
2422, -150.33107, 60, -207.01427
2423, -128.47471, 60, -192.73729
2424, -115.91062, 60, -165.34006
2425, -107.76546, 60, -151.95968
2426, -129.29502, 60, -128.08071
2427, -31.444863, 60, -190.30305
2428, -18.627994, 60, -192.11042
2429, -44.610613, 60, -212.12121
2430, 37.302913, 60, -214.60176
2431, 39.587181, 60, -207.70943
2432, -99.518153, 60, 234.91512
2433, -54.501979, 60, 273.44915
2434, -64.123985, 60, 250.30669
2435, -249.44327, 60, 83.139738
2436, -107.59396, 60, -240.18173
2437, 739.04242, 60, 68.088896
2438, 123.47405, 60, -224.08187
2439, -15.463365, 60, 285.01972
2440, 806.96516, 60, -126.60738
2441, 1047.1408, 60, 78.658171
2442, 1128.2964, 60, -82.45556
2443, 356.07279, 60, 121.56498
2444, 148.65784, 60, 212.57612
2445, 53.249205, 60, 261.95244
2446, -38.612551, 60, 209.71346
2447, -51.78067, 60, 215.07685
2448, -40.429507, 60, 198.78472
2449, -245.0242, 60, 42.379755
2450, -207.05929, 60, -40.178437
2451, -209.73761, 60, -49.287151
2452, -192.93663, 60, -42.976886
2453, 1100.4329, 60, 83.859126
2454, -165.8685, 60, -80.235463
2455, -38.880234, 60, -175.77306
2456, -40.962012, 60, -239.86701
2457, -49.53473, 60, -232.5664
2458, -222.96117, 60, -137.6107
2459, -67.205883, 60, 166.55371
2460, -37.630888, 60, -250.70719
2461, -50.855538, 60, -252.66093
2462, -220.85657, 60, 151.38313
2463, -202.43454, 60, 190.7955
2464, -112.48739, 60, -216.66882
2465, -89.877127, 60, -225.20484
2466, -272.86155, 60, -38.145221
2467, -208.89206, 60, -180.61488
2468, 143.82577, 60, 184.1828
2469, 113.79428, 60, 201.57807
2470, 755.50162, 60, 96.710308
2471, 364.70025, 60, -110.03892
2472, -147.11474, 60, -221.76337
2473, -126.27604, 60, 209.55304
2474, 0.15946178, 60, -278.2387
2475, -22.07921, 60, 272.07149
2476, -25.401602, 60, 286.2869
2477, -104.51191, 60, 130.49864
2478, -46.715104, 60, 283.49279
2479, 899.58317, 60, -125.28599
2480, 340.36479, 60, 77.238289
2481, 1210.3425, 60, -103.75077
2482, 1289.075, 60, -21.571834
2483, 1127.6709, 60, 119.63681
2484, -227.34904, 60, -90.296423
2485, -217.70567, 60, -106.34206
2486, -116.32475, 60, 200.32209
2487, -101.40203, 60, 151.94786
2488, -263.37066, 60, -45.63979
2489, 178.58764, 60, 152.14683
2490, 794.43315, 60, 127.74073
2491, 352.104, 60, -34.957927
2492, 352.47623, 60, 14.74969
2493, -100.78684, 60, 169.17453
2494, 767.65087, 60, -90.556896
2495, 302.6373, 60, 60.579944
2496, -25.361069, 60, 262.39679
2497, -39.804323, 60, 263.29503
2498, -50.678156, 60, 240.35667
2499, -255.92185, 60, 51.548625
2500, -244.63952, 60, 55.931957
2501, 234.60759, 60, 159.12469
2502, 234.50591, 60, 116.09068
2503, -227.75626, 60, -46.453042
2504, -234.29686, 60, -38.470555
2505, -189.72698, 60, 14.167021
2506, -84.888071, 60, -149.2394
2507, -184.79498, 60, -58.326666
2508, -51.7738, 60, -186.40038
2509, -79.590779, 60, -169.0852
2510, 27.813967, 60, -174.39873
2511, 10.687245, 60, -163.97913
2512, 164.20126, 60, -166.03362
2513, 125.79201, 60, -190.67123
2514, 71.11259, 60, -170.14687
2515, -213.91652, 60, -122.30897
2516, -9.8847713, 60, -189.21397
2517, 55.244077, 60, -243.5433
2518, 19.703619, 60, -183.93457
2519, 22.400819, 60, -196.16507
2520, 205.73315, 60, -150.14814
2521, -3.6446895, 60, -179.3867
2522, 30.186805, 60, -196.36677
2523, -244.49837, 60, -42.965995
2524, 254.78144, 60, 63.300193
2525, -179.25958, 60, 8.6617969
2526, -110.14246, 60, -174.81353
2527, 36.255668, 60, -179.23564
2528, 95.541206, 60, -204.00458
2529, 226.76804, 60, -103.28025
2530, 257.82353, 60, -132.10967
2531, 309.39983, 60, -118.65622
2532, 248.94771, 60, -40.854973
2533, -216.734, 60, 138.95981
2534, 50.163756, 60, 224.10712
2535, 49.360103, 60, 213.1956
2536, 35.447055, 60, 242.6079
2537, 42.029636, 60, 236.38335
2538, -69.554489, 60, -201.31115
2539, -76.98986, 60, -186.78116
2540, 47.553779, 60, 193.84983
2541, -199.59869, 60, -106.73081
2542, -13.649156, 60, 164.8531
2543, -29.978384, 60, 177.13429
2544, -97.371469, 60, -183.99597
2545, 50.409781, 60, -220.44686
2546, 25.82756, 60, -256.51773
2547, 25.21313, 60, -267.32954
2548, -81.661534, 60, 223.80715
2549, -100.52292, 60, 211.36027
2550, 36.644301, 60, -191.2198
2551, 38.685787, 60, -198.81508
2552, 46.044677, 60, -202.56245
2553, 44.754649, 60, -181.68395
2554, -216.13106, 60, 124.13875
2555, 57.837162, 60, 202.44701
2556, -276.75446, 60, 37.413846
2557, -69.585183, 60, -245.26925
2558, -222.66851, 60, 106.01159
2559, -98.468128, 60, 189.21411
2560, -84.985009, 60, 180.21272
2561, 1194.2293, 30, 60
2562, 1171.7367, 30, 60
2563, 73.54837, 60, -233.42606
2564, 1039.0513, 60, -6.0086043
2565, 1037.0551, 60, -31.791439
2566, -222.18141, 60, -56.784345
2567, -230.10343, 60, -58.394333
2568, -76.599878, 60, -234.8457
2569, -61.201357, 60, -231.3972
2570, 1213.4773, 30, 58.225665
2571, 1253.5111, 45.751461, 26.260195
2572, 1258.356, 45.138231, 12.490009
2573, -107.54154, 60, -192.50949
2574, -186.66841, 60, -76.842994
2575, -201.51441, 60, -72.247575
2576, 1254.3756, 60, 56.691647
2577, -156.36397, 60, 95.333829
2578, -124.60207, 60, -111.58381
2579, 1053.2325, 60, -46.754545
2580, 1033.5666, 60, -52.790723
2581, -231.65805, 60, 87.557904
2582, -237.75195, 60, 69.518993
2583, -226.8543, 60, 60.350122
2584, -210.97719, 60, 92.390842
2585, 34.177112, 60, -279.43186
2586, -212.08478, 60, -61.228442
2587, 334.15884, 60, -76.624493
2588, -171.82311, 60, 95.162907
2589, -115.70372, 60, -201.91973
2590, -39.085415, 60, 183.90599
2591, -48.452135, 60, 187.81302
2592, 1066.4009, 60, -64.711041
2593, 1145.9164, 30, 60
2594, 1121.6631, 30, 56.792507
2595, -182.58794, 60, -94.156372
2596, 70.720866, 60, 197.65874
2597, 97.186555, 60, 192.7005
2598, -241.97429, 60, -55.298144
2599, -250.79438, 60, -50.20111
2600, -260.84658, 60, -57.971939
2601, -236.39945, 60, -65.629448
2602, 1029.3371, 60, -82.772261
2603, -278.58675, 60, -1.5882985
2604, -237.91941, 60, -79.27729
2605, -213.95821, 60, -79.74477
2606, -66.231261, 60, 201.47203
2607, -68.215704, 60, 213.85712
2608, 266.89288, 60, 0.81159313
2609, 296.80358, 60, -43.575222
2610, 61.553536, 60, -215.13841
2611, 81.228415, 60, -219.12756
2612, -67.210942, 60, 237.41197
2613, -249.79027, 60, -76.181101
2614, 1176.6287, 30, -60
2615, 1197.7849, 30, -60
2616, 1106.5396, 60, -81.1638
2617, 1263.8664, 60, 42.601371
2618, 1131.3773, 30, -58.864794
2619, 1153.2064, 30, -60
2620, 83.546372, 60, -185.71692
2621, 1113.2615, 30, -53.312458
2622, 72.52719, 60, 217.00451
2623, 1069.8268, 60, -86.332475
2624, 51.509366, 60, 234.06901
2625, -64.88717, 60, 186.5933
2626, 58.024204, 60, 249.11204
2627, 66.158324, 60, 236.83581
2628, -2.2927874, 39.007178, 257.2478
2629, 7.5755766, 38.425203, 256.81441
2630, 1.4677651, 31.653855, 257.2478
2631, -81.493301, 60, -211.33279
2632, -133.42056, 60, -216.89662
2633, 1038.0166, 60, 20.343956
2634, 1036.2387, 60, 52.194931
2635, 1086.4837, 60, -83.289686
2636, -189.83045, 60, 60.986272
2637, -56.549425, 60, -222.14285
2638, 56.799799, 60, -185.26985
2639, -56.27724, 60, -210.95201
2640, 1081.0569, 45.389611, -8.0293985
2641, 79.042028, 60, 232.04755
2642, 58.089826, 60, -206.14835
2643, -213.41337, 60, 59.453706
2644, -196.38382, 60, 75.469725
2645, 57.188432, 60, -197.254
2646, -187.39428, 60, 93.923408
2647, 102.01862, 60, 221.09382
2648, -22.235968, 16.832678, 208.97316
2649, -18.585432, 26.538814, 204.48767
2650, -24.303111, 27.796324, 211.56527
2651, 57.551457, 330, -138.24346
2652, 145.93569, 318.55362, 34.069369
2653, 148.08375, 318.553, -16.21827
2654, 3.8328477, 264.1734, -149.87324
2655, -16.251575, 264.17516, -148.92882
2656, 59.455776, 330.01451, 137.22032
2657, -56.960301, 330, -138.56105
2658, -109.38492, 322.05015, -102.05592
2659, -133.91418, 322.04663, -67.184179
2660, -147.62187, 323.76333, -20.019744
2661, -146.56976, 323.7593, 28.76315
2662, -144.15698, 285.822, -39.868283
2663, -130.48895, 321.56638, 73.137859
2664, -100.12038, 321.56089, 110.39066
2665, -137.58596, 285.32475, 57.572375
2666, -57.622152, 330.01317, 138.20543
2667, -1.1136686, 271.33708, 149.86879
2668, 18.99395, 271.33933, 148.66489
2669, -100.44488, 80.684271, 110.41257
2670, -116.74188, 80.682233, 94.115569
2671, -128.16205, 80.848894, 76.253745
2672, -139.04096, 80.848469, 53.999267
2673, -121.09444, 101.52993, 87.558727
2674, -146.3888, 81.22991, 31.984558
2675, -148.39733, 81.230377, 14.224098
2676, -141.13197, 102.07707, 48.074249
2677, -149.33365, 81.789154, -5.9140756
2678, -147.33517, 81.789154, -23.651138
2679, -149.40824, 103.01953, 5.2520767
2680, -142.75231, 80.683518, -43.392482
2681, -136.66747, 80.683188, -60.781876
2682, -145.67933, 102.47267, -35.079624
2683, -126.21944, 78.028016, -79.337628
2684, -112.4131, 78.027545, -98.43674
2685, -129.82023, 98.710538, -73.663942
2686, -97.01911, 78.670586, -113.83257
2687, -78.189631, 78.672435, -126.96416
2688, -103.41529, 96.703102, -107.48807
2689, -58.367625, 81.771401, -137.55974
2690, -35.8709, 81.769455, -145.43171
2691, -67.580522, 100.43999, -133.66131
2692, -16.088839, 79.212351, -148.26041
2693, 1.6934781, 79.209427, -149.88236
2694, -27.096791, 100.9809, -147.10303
2695, 23.045873, 78.565003, -147.47408
2696, 40.828923, 78.566196, -143.68729
2697, 14.379279, 97.774324, -148.52373
2698, 65.533501, 82.837484, -134.82286
2699, 89.984278, 82.843096, -119.56528
2700, 60.478809, 101.41955, -136.87946
2701, 147.60928, 97.263652, -21.218271
2702, 147.53791, 97.265059, 21.851691
2703, 137.05327, 93.071895, 59.708939
2704, 114.75594, 93.069969, 96.137007
2705, 142.65904, 130.33893, 43.777648
2706, 91.609647, 85.200029, 118.55088
2707, 68.912172, 85.200015, 132.81265
2708, 105.76573, 118.27083, 105.19945
2709, 11.589934, 77.13632, 148.7594
2710, -5.1052489, 77.134478, 149.49004
2711, -23.880037, 76.84206, 147.37353
2712, -46.283158, 76.842205, 141.77363
2713, -14.397259, 93.976478, 148.50724
2714, 106.12678, 318.6527, -104.99879
2715, 71.976287, 288.64962, -130.63898
2716, 64.572522, 286.37053, 134.6246
2717, 98.532668, 316.37053, 111.83759
2718, -67.86528, 291.56055, 132.83737
2719, 133.76667, 318.65453, -67.592188
2720, 124.68337, 316.37535, 81.666414
2721, -84.294219, 79.374093, 123.13044
2722, -92.761671, 100.05393, 117.81435
2723, -67.37092, 79.372099, 133.76404
2724, -75.571595, 292.04369, -128.6955
2725, 62.61893, 257.67748, 135.77489
2726, 114.15939, 92.557438, -96.732088
2727, 136.53539, 92.561493, -61.187724
2728, 146.14007, 129.82793, -33.7074
2729, 108.54692, 115.39673, -102.41002
2730, 48.364848, 76.069246, 141.04291
2731, 29.193659, 76.066512, 146.77187
2732, -54.524367, 96.222136, 138.94756
2733, 22.115677, 93.203486, 147.63464
2734, -47.01796, 230.96243, -141.97506
2735, -50.685173, 266.78897, -140.79844
2736, -83.128941, 262.68001, 124.39836
2737, -33.970868, 271.1295, 145.25186
2738, 35.782966, 114.46074, 145.41659
2739, 18.224444, 115.52754, 148.15811
2740, -139.40593, 252.91926, -52.871918
2741, -149.70245, 254.62569, -2.6408034
2742, 48.205762, 215.22416, 141.51261
2743, 92.359673, 230.27168, 117.70274
2744, -14.523406, 242.45413, 149.04271
2745, 60.69279, 101.26696, 136.80413
2746, -136.75074, 123.12838, 60.524438
2747, -144.56069, 123.51061, 38.326764
2748, -148.10065, 129.81709, 16.857273
2749, -149.61372, 130.37586, -3.4283394
2750, -146.50611, 150.86531, 30.516556
2751, -146.95187, 129.48085, -26.963552
2752, -141.66102, 128.37522, -46.625124
2753, -148.318, 156.27841, -14.92823
2754, -134.25874, 123.16917, -66.667421
2755, -122.78599, 120.51479, -84.918907
2756, -137.3442, 150.17712, -58.822813
2757, -109.92354, 114.48706, -101.0308
2758, -94.23785, 115.12906, -116.43182
2759, -115.98801, 138.94196, -95.036412
2760, -75.395359, 128.35838, -128.86512
2761, -55.131382, 131.45915, -138.83999
2762, -83.600566, 146.14201, -123.76143
2763, -33.370386, 127.79442, -145.97212
2764, -13.349304, 125.23672, -148.74438
2765, -42.644656, 155.71636, -143.28148
2766, 6.2476309, 116.19204, -149.5101
2767, 27.818196, 115.55013, -147.07724
2768, -0.32287702, 143, -149.94847
2769, -105.28901, 258.84667, -105.96965
2770, 47.945236, 120.66128, -141.32242
2771, 72.227455, 124.93736, -130.84565
2772, 39.94993, 139.07185, -144.17488
2773, 93.707861, 258.41802, -116.38783
2774, 40.941144, 269.75824, -143.49942
2775, 104.9132, 156.96542, 106.16288
2776, 78.766825, 149.10032, 126.80731
2777, -40.929604, 112.52042, 143.75308
2778, -62.508825, 115.04821, 136.20968
2779, -102.67911, 244.12283, 108.37061
2780, -71.568475, 223.68608, 131.08614
2781, -79.480195, 123.40922, 126.28399
2782, -96.461591, 124.71702, 114.39685
2783, -66.765453, 139.70784, 133.96135
2784, 23.99709, 233.92393, -147.91487
2785, -113.88738, 126.39131, 97.101074
2786, -126.13635, 126.55702, 79.60346
2787, -131.51782, 147.98706, 71.097893
2788, -102.74523, 149.73866, 108.31014
2789, -3.4451366, 111.1488, 149.78762
2790, -22.344828, 110.85731, 147.67606
2791, -30.500325, 129.68692, 146.68843
2792, 10.718598, 132.41202, 149.06812
2793, 57.193954, 123.58891, 138.09485
2794, 136.83086, 274.92843, 59.629628
2795, 144.55887, 277.20855, -38.699175
2796, 55.342838, 162.29727, 138.85775
2797, -147.98972, 216.48953, 17.722461
2798, -145.92744, 249.37844, 34.627796
2799, 113.72094, 195.754, 97.466312
2800, 125.04232, 238.25944, 81.444855
2801, 146.30175, 240.43042, 31.580506
2802, 134.13285, 164.95027, 66.982799
2803, -35.447777, 212.45629, 145.11223
2804, -2.2098638, 212.66088, 149.90522
2805, -126.46837, 247.17483, 79.320156
2806, -119.50517, 208.19473, 89.676973
2807, -38.380517, 193.85792, -144.44641
2808, -72.37851, 196.48201, -130.74645
2809, 110.10773, 230.6886, -101.17965
2810, 81.856595, 211.80112, -125.04913
2811, -107.01091, 221.88358, -104.25123
2812, -126.66779, 247.14233, -79.028032
2813, 48.74782, 213.63377, -141.3182
2814, 11.349343, 208.04512, -149.26214
2815, 69.26355, 185.9296, -132.45699
2816, 146.61437, 169.14798, 29.487348
2817, 148.23014, 168.30903, -15.707976
2818, 148.92663, 202.93372, 9.5264663
2819, 148.53197, 239.59457, -13.029209
2820, 138.08112, 163.60424, -56.800399
2821, -140.95232, 215.96055, -48.859742
2822, 116.81154, 154.59648, -93.833519
2823, 128.52486, 193.07609, -75.985309
2824, -149.40193, 189.45424, -5.3080696
2825, -146.19377, 184.2095, 32.876084
2826, -84.595238, 169.93816, -123.20598
2827, -92.637678, 207.0388, -117.53711
2828, -130.30858, 181.3291, 73.114197
2829, -107.31379, 178.27327, 103.82336
2830, 32.588089, 185.20148, 145.94159
2831, 92.691468, 144.87896, -117.71461
2832, 7.5618071, 169.88723, -149.5294
2833, 27.644265, 160.85408, -147.2694
2834, -58.923377, 193.86926, 137.6988
2835, 134.42959, 239.7006, -66.181516
2836, -139.34832, 177.89904, 53.352738
2837, -117.39264, 195.34041, -92.823073
2838, -146.67659, 188.55887, -28.832803
2839, -89.160976, 176.59887, 120.3566
2840, 4.3352968, 159.70938, 149.7988
2841, -137.77742, 182.78911, -57.522907
2842, -17.059272, 155.34202, 148.44104
2843, -128.02259, 177.58503, -76.742012
2844, -55.305921, 165.35368, 138.87976
2845, -16.153163, 190.1995, -148.67591
2846, -116.87215, 162.72964, -93.712992
2847, -102.32145, 156.70399, -108.75388
2848, -35.889119, 157.00311, 145.22099
2849, 47.881294, 165.96799, -141.47959
2850, 80.891624, 164.12733, -125.51613
2851, 0, 300, -121.27713
2852, 0, 300, 121.27713
2853, 20, 330, 121.27713
2854, 20, 330, -121.27713
2855, -55.633073, 360, -106.05423
2856, -118.96537, 360, 18.937639
2857, -117.62653, 360, -28.21341
2858, -54.362126, 360, 107.19738
2859, -104.55968, 360, -58.270812
2860, -108.78947, 360, 51.134356
2861, -80.175192, 360, -92.020312
2862, -81.795204, 360, 89.59185
2863, 56.179241, 360, -105.56298
2864, 119.58888, 360, -20.383901
2865, 117.07637, 360, 28.2319
2866, 104.67621, 360, 59.356938
2867, 81.386078, 360, 90.60244
2868, 55.865536, 360, 105.84514
2869, 108.04423, 360, -51.61008
2870, 82.555302, 360, -89.263335
2871, -20, 330, -121.27713
2872, -20, 330, 121.27713
2873, -9.8897589, 278.92, -95.283549
2874, 10.226835, 278.92008, -95.236078
2875, 48.150117, 330, -82.515556
2876, 4.8393448, 276.88097, 95.783285
2877, -15.339589, 276.88301, 94.512755
2878, 47.165896, 330, 83.215452
2879, -49.366149, 330, 81.650815
2880, -46.040283, 330, -84.015895
2881, -74.546912, 326.66286, -59.12984
2882, -52.319783, 296.66285, -79.602575
2883, -56.029465, 279.90896, 76.990759
2884, -81.06619, 309.91007, 51.039604
2885, -90.88756, 326.66405, -29.515099
2886, 63.309921, 26.058736, 71.422124
2887, 79.483679, 26.059625, 52.791482
2888, 92.018583, 28.880435, 26.587643
2889, 95.282654, 28.881235, -5.4487877
2890, 87.748315, 54.93801, 36.920625
2891, -94.364431, 24.772986, 12.423383
2892, -86.825295, 24.772986, 39.121622
2893, 87.906885, 29.090832, -36.51435
2894, 70.298652, 29.08973, -64.764954
2895, 92.985802, 57.972067, -22.815988
2896, 46.823756, 26.274667, -83.66028
2897, 17.834909, 26.275208, -93.7088
2898, 57.893721, 55.364356, -75.613434
2899, -7.5266916, 23.747997, -95.060438
2900, -30.459811, 23.748994, -90.43512
2901, 5.9076232, 50.022039, -95.330399
2902, -54.165624, 23.080916, -78.435203
2903, -72.166785, 23.082372, -62.323785
2904, -44.761873, 46.823713, -84.541419
2905, -86.126621, 23.259239, -40.806996
2906, -94.156641, 23.260376, -14.001704
2907, -95.326593, 48.032014, 5.1150372
2908, -83.179736, 46.346439, -47.82347
2909, 52.115296, 301.2978, -79.74074
2910, 76.198962, 331.2978, -57.081469
2911, 74.915809, 325.60927, 58.675762
2912, 51.623291, 295.60927, 80.09951
2913, -93.357237, 309.91121, 19.432278
2914, -49.912992, 256.77138, 81.376478
2915, 91.490809, 325.6108, 28.122422
2916, 92.560194, 331.29956, -25.195711
2917, -71.992787, 25.898346, 62.553624
2918, -48.975003, 25.897718, 82.404593
2919, -27.163179, 20.368623, 91.796175
2920, -3.0207976, 20.36774, 95.646342
2921, 19.3202, 23.854426, 93.508024
2922, 41.41866, 23.855353, 85.895956
2923, -38.493724, 46.266613, 87.137037
2924, 8.6292343, 44.222835, 94.959554
2925, -77.000757, 50.668361, 56.054207
2926, 53.031061, 49.911216, 79.338114
2927, 62.386245, 272.06502, 72.427326
2928, 30.310567, 276.45227, 90.268116
2929, 14.422556, 253.32923, 94.604052
2930, -66.447296, 270.16337, -69.226144
2931, -34.385057, 273.50244, -88.823559
2932, 76.897178, 255.36953, 56.339408
2933, 58.807118, 236.20931, 75.083871
2934, 36.816767, 273.94823, -87.957308
2935, 67.842221, 275.24818, -67.494722
2936, 26.518617, 252.87211, -91.661658
2937, -23.990948, 252.42581, -92.56206
2938, 28.431496, 229.21789, 91.025055
2939, 2.4033236, 229.64765, 95.820255
2940, -83.476622, 261.62239, -46.760611
2941, -69.818136, 238.46791, -65.111986
2942, 79.380121, 249.46754, -53.170816
2943, 89.198714, 276.80716, -33.506386
2944, 81.069382, 81.257118, 50.785332
2945, 92.898097, 84.079387, 23.386889
2946, 95.365697, 305.50673, -4.777202
2947, 92.295239, 271.12316, 26.139533
2948, 40.747583, 70.979378, 86.236024
2949, 63.112058, 73.183058, 71.630734
2950, 72.871564, 102.32074, 61.491974
2951, -25.678054, 228.83404, -92.005691
2952, 0.66759822, 234.24789, -95.816654
2953, -11.806652, 67.554929, 94.591685
2954, 11.334264, 71.038363, 94.661408
2955, -35.959856, 73.080389, 88.221934
2956, 26.842454, 229.27852, -91.590464
2957, 20.423231, 94.296691, 93.503383
2958, 63.787462, 85.714888, -71.127579
2959, 37.563903, 82.9026, -87.57046
2960, 11.026937, 76.243103, -94.713121
2961, -15.113342, 73.718408, -94.169678
2962, -36.079934, 66.963072, -88.164135
2963, -59.406538, 66.298213, -74.465784
2964, -30.568741, 93.178995, -90.481493
2965, -76.141235, 71.280411, -57.196903
2966, -88.772532, 71.458108, -34.462934
2967, -69.353512, 91.417422, -65.919458
2968, -94.123379, 276.56228, -13.926377
2969, -95.546318, 244.87614, -3.4460566
2970, 94.591556, 88.465746, -10.698194
2971, 85.451679, 88.674611, -42.495805
2972, 19.540877, 106.58943, -93.647403
2973, 33.057068, 196.78207, -89.439433
2974, 59.005305, 215.39832, -74.953329
2975, 95.714437, 114.78013, 2.1690671
2976, 83.923972, 216.95013, -45.804619
2977, 71.039446, 116.20106, -63.797238
2978, 87.126939, 178.44216, -38.467729
2979, 95.908051, 212.51109, 0.69842039
2980, -73.276729, 209.26729, -60.885454
2981, -51.194277, 217.80749, -80.526275
2982, -91.273734, 194.84295, -28.536451
2983, -78.828666, 174.19786, -53.807153
2984, -26.535731, 199.63582, -91.754974
2985, -11.605986, 207.53268, 94.920749
2986, -25.627905, 231.65462, 92.018271
2987, 80.037494, 151.0313, -52.206436
2988, 94.951736, 146.58841, -7.9623591
2989, -84.503876, 81.573249, 44.700859
2990, -67.883287, 82.698787, 67.749677
2991, 50.739099, 212.53351, 80.858208
2992, 92.305695, 142.20205, 25.997314
2993, -49.364452, 103.97952, 82.005526
2994, 55.324476, 148.07521, -77.696603
2995, -94.706016, 71.133474, -9.828786
2996, -93.743128, 72.645653, 17.142648
2997, -90.095444, 104.67374, 31.299282
2998, 34.680634, 169.22769, -88.878506
2999, 21.570835, 134.40638, -93.406219
3000, -7.1244389, 127.75375, -95.338266
3001, -1.9269757, 183.1122, -95.856678
3002, -93.255356, 96.07056, -20.746046
3003, 88.137758, 196.76416, 36.098988
3004, 92.912841, 235.26989, 22.87637
3005, -31.526943, 172.09457, -90.030085
3006, 50.3383, 123.6919, 81.282175
3007, 72.38493, 131.76445, 62.110262
3008, -4.6519945, 181.3444, 95.779637
3009, -33.079013, 183.35545, 89.456694
3010, -54.345262, 160.67782, -78.374908
3011, -30.208646, 144.14993, -90.551432
3012, 63.644371, 186.32986, 71.35862
3013, 32.887927, 179.33187, 89.532212
3014, -32.428509, 116.33475, -89.741666
3015, -52.841515, 109.58853, -79.524154
3016, -93.990105, 209.79436, 15.077513
3017, -71.646915, 114.57215, -63.049331
3018, -83.002071, 146.25812, -48.059414
3019, -90.282563, 128.08029, -30.868773
3020, 82.7598, 163.57175, 48.589184
3021, -52.404708, 135.39186, 79.794417
3022, -17.448513, 125.76763, 93.972899
3023, 23.6067, 123.75967, 92.939064
3024, -52.328265, 167.59773, 79.798406
3025, -58.951069, 193.77687, 74.968892
3026, 16.961042, 155.16119, 94.088788
3027, -81.431293, 218.91649, 50.464259
3028, -93.31215, 168.89216, 20.137279
3029, -95.213773, 127.75512, -5.971987
3030, -91.988587, 136.67694, 26.757867
3031, -68.507372, 234.68664, 66.737362
3032, -75.549243, 145.80765, 58.049924
3033, 463.16761, 30, -54.243533
3034, 452.54045, 30, -20.922385
3035, 451.43427, 30, 11.812209
3036, 459.77961, 30, 45.310122
3037, 476.96401, 30, 74.917428
3038, 504.12756, 30, 99.962753
3039, 534.03117, 30, 113.82467
3040, 568.00964, 30, 119.1251
3041, 600.37424, 30, 115.20363
3042, 632.35734, 30, 101.80761
3043, 510.16018, 30, -103.1289
3044, 482.67171, 30, -81.783334
3045, 657.62247, 30, 81.522713
3046, 677.43576, 30, 52.652592
3047, 687.51327, 30, 20.479922
3048, 688.19721, 30, -14.847244
3049, 679.84781, 30, -46.292537
3050, 662.13891, 30, -76.217078
3051, 638.69366, 30, -98.292191
3052, 606.90866, 30, -113.59302
3053, 574.54608, 30, -119.1251
3054, 540.28648, 30, -115.36649
3055, 845.6802, 30, 70.79095
3056, 869.46714, 30, 83.934767
3057, 895.66083, 30, 89.428736
3058, 919.11996, 30, 87.482805
3059, 939.17434, 30, 80.355354
