3998, 1534, 5232
1766, 353, 508, 614, 399, 3593, 2623, 4967, 
1523, 3595, 4485
1767, 603, 735, 343, 574, 5326, 3125, 2519, 
2522, 5328, 2286
1768, 193, 192, 84, 925, 1141, 2006, 2031, 
3746, 5048, 3882
1769, 928, 591, 845, 847, 4008, 3774, 3920, 
3899, 3830, 3917
1770, 99, 877, 504, 207, 5124, 4829, 5125, 
2028, 4685, 2098
1771, 583, 362, 417, 92, 3787, 1783, 4924, 
4942, 1358, 1674
1772, 928, 888, 924, 847, 3900, 4754, 4009, 
3899, 3902, 3832
1773, 234, 67, 244, 233, 2042, 5203, 2302, 
1182, 1978, 2136
1774, 584, 879, 909, 877, 4071, 4900, 5444, 
4687, 4862, 4917
1775, 457, 875, 878, 482, 4615, 3557, 4517, 
1865, 5120, 4518
1776, 357, 837, 454, 434, 4522, 4530, 1710, 
1589, 4466, 1709
1777, 208, 209, 505, 42, 1157, 2101, 2100, 
1984, 1937, 3808
1778, 908, 826, 822, 823, 5166, 3478, 4819, 
4549, 3477, 3471
1779, 413, 748, 168, 167, 5060, 3186, 1469, 
1470, 3185, 1116
1780, 844, 368, 792, 845, 4929, 3775, 3554, 
4868, 4930, 5445
1781, 322, 699, 690, 645, 5310, 2948, 4054, 
2730, 5041, 4055
1782, 550, 399, 832, 866, 4553, 4289, 4663, 
4474, 4290, 3834
1783, 915, 875, 878, 914, 3558, 3557, 3561, 
3906, 4498, 4512
1784, 489, 496, 900, 930, 3540, 3543, 3541, 
5318, 5446, 3888
1785, 448, 176, 878, 420, 1687, 5447, 4519, 
1686, 1484, 5040
1786, 793, 105, 368, 792, 3358, 1372, 5015, 
3360, 3356, 3775
1787, 397, 835, 833, 509, 3661, 1751, 4080, 
4051, 4050, 3969
1788, 909, 584, 877, 206, 5444, 4687, 4917, 
5311, 2328, 4686
1789, 915, 719, 744, 878, 4069, 3171, 5448, 
3561, 4068, 4857
1790, 902, 904, 745, 733, 4938, 4825, 5288, 
5254, 4824, 3176
1791, 385, 935, 459, 454, 4563, 3663, 1729, 
1728, 4528, 1831
1792, 203, 94, 897, 202, 2033, 4645, 4056, 
1151, 2022, 4057
1793, 171, 170, 417, 750, 1119, 1478, 1477, 
3194, 3192, 4491
1794, 89, 198, 752, 492, 2032, 4353, 4354, 
2069, 2068, 4629
1795, 565, 362, 597, 416, 5129, 5442, 2589, 
4658, 1802, 4659
1796, 566, 901, 758, 565, 4471, 4427, 4358, 
2423, 4660, 5202
1797, 296, 297, 832, 549, 1245, 1890, 2640, 
2223, 2222, 4702
1798, 890, 418, 483, 443, 4382, 1856, 4421, 
4521, 1660, 1857
1799, 529, 868, 530, 371, 3571, 4299, 2376, 
5384, 5367, 4915
1800, 550, 399, 508, 151, 4553, 3595, 2635, 
4662, 1440, 5278
1801, 895, 605, 606, 586, 4920, 2624, 4181, 
4182, 2627, 2626
1802, 698, 637, 636, 708, 3710, 2705, 4110, 
2992, 4092, 4093
1803, 698, 320, 636, 637, 3708, 2702, 4110, 
3710, 2703, 2705
1804, 353, 528, 399, 614, 4117, 4118, 1523, 
4967, 2580, 4485
1805, 929, 860, 862, 392, 3873, 5397, 4587, 
4459, 4134, 4269
1806, 935, 837, 459, 454, 3641, 3662, 3663, 
4528, 4530, 1831
1807, 837, 446, 459, 454, 3681, 1883, 3662, 
4530, 1712, 1831
1808, 681, 319, 706, 679, 3717, 4826, 2971, 
2895, 3718, 2970
1809, 486, 837, 446, 459, 3639, 3681, 1882, 
1910, 3662, 1883
1810, 644, 702, 706, 707, 4339, 2977, 4827, 
4338, 2994, 2987
1811, 319, 320, 636, 679, 1268, 2702, 2701, 
3718, 3646, 5449
1812, 320, 698, 636, 679, 3708, 4110, 2702, 
3646, 2945, 5449
1813, 854, 855, 488, 856, 4449, 4451, 4452, 
3578, 4105, 5181
1814, 891, 896, 887, 830, 3608, 3505, 4385, 
3849, 3502, 3503
1815, 462, 856, 470, 488, 4103, 3994, 1840, 
1933, 5181, 1916
1816, 888, 923, 924, 847, 3679, 3829, 4754, 
3902, 3828, 3832
1817, 928, 591, 849, 845, 4008, 4859, 4262, 
3920, 3774, 3651
1818, 584, 905, 877, 504, 4650, 4828, 4687, 
2438, 4164, 4829
1819, 905, 618, 906, 557, 4652, 4174, 4429, 
4166, 2620, 4430
1820, 441, 405, 458, 848, 1808, 1915, 1775, 
5091, 3767, 4729
1821, 556, 907, 618, 557, 4231, 4173, 2638, 
2514, 4776, 2620
1822, 852, 439, 892, 887, 3619, 3618, 3622, 
4384, 4267, 4268
1823, 876, 721, 421, 873, 4906, 3760, 4909, 
4015, 3759, 3763
1824, 659, 658, 634, 702, 2772, 2767, 2770, 
5134, 5141, 5004
1825, 234, 235, 514, 68, 1183, 2348, 2305, 
2050, 2051, 5261
1826, 905, 879, 481, 906, 4651, 5421, 4167, 
4429, 4961, 4428
1827, 879, 873, 481, 906, 4960, 4198, 5421, 
4961, 4962, 4428
1828, 879, 876, 469, 873, 4400, 4397, 4398, 
4960, 4015, 4197
1829, 683, 682, 161, 875, 2901, 2897, 2899, 
4431, 4433, 5317
1830, 811, 933, 810, 128, 3896, 4537, 3431, 
3429, 5450, 3427
1831, 406, 429, 558, 444, 1872, 4845, 4590, 
1871, 1663, 4591
1832, 682, 635, 317, 634, 3811, 2698, 4949, 
5003, 2700, 2696
1833, 703, 633, 658, 634, 5144, 2766, 5239, 
5436, 2697, 2767
1834, 485, 873, 469, 442, 4196, 4197, 1875, 
1876, 4932, 1770
1835, 378, 938, 829, 73, 5355, 4252, 4506, 
1777, 5354, 4508
1836, 457, 485, 442, 912, 1884, 1876, 1826, 
5082, 5073, 4332
1837, 615, 928, 927, 924, 4006, 4487, 3983, 
4007, 4009, 5180
1838, 909, 363, 881, 904, 4324, 4244, 4325, 
4937, 4247, 4245
1839, 450, 444, 404, 559, 1908, 1877, 1878, 
3737, 3738, 3826
1840, 721, 876, 740, 739, 4906, 4843, 3144, 
3143, 4019, 3151
1841, 319, 644, 318, 681, 2727, 2726, 1267, 
3717, 5138, 4223
1842, 686, 4, 641, 3, 5451, 2719, 4005, 
4779, 945, 2714
1843, 686, 4, 619, 641, 5451, 2653, 5452, 
4005, 2719, 2795
1844, 308, 154, 688, 844, 4205, 2917, 5022, 
4206, 4207, 4213
1845, 308, 309, 680, 846, 1257, 4258, 5453, 
3770, 3686, 3748
1846, 664, 626, 651, 712, 2786, 2746, 2787, 
4666, 4568, 4763
1847, 308, 309, 626, 680, 1257, 2672, 2671, 
5453, 4258, 4567
1848, 378, 379, 124, 805, 1604, 1396, 1393, 
3742, 5376, 3413
1849, 11, 676, 26, 25, 4969, 2881, 2859, 
2857, 2885, 971
1850, 716, 661, 701, 665, 3929, 5404, 3022, 
5343, 2791, 5081
1851, 727, 449, 426, 183, 5369, 1723, 5006, 
3102, 1689, 1497
1852, 725, 424, 882, 180, 4437, 4140, 4438, 
3095, 1494, 4142
1853, 676, 10, 621, 11, 4592, 2658, 4593, 
4969, 952, 2659
1854, 716, 665, 701, 648, 5343, 5081, 3022, 
4643, 2792, 4644
1855, 661, 716, 701, 643, 3929, 3022, 5404, 
2778, 4453, 3521
1856, 395, 427, 61, 228, 1513, 1502, 1514, 
3572, 5069, 1969
1857, 660, 694, 674, 700, 3730, 2936, 4738, 
3731, 2956, 2952
1858, 751, 91, 90, 492, 4742, 1039, 4632, 
4631, 2016, 2015
1859, 830, 809, 887, 892, 3495, 5216, 3503, 
4259, 5215, 4268
1860, 872, 890, 911, 899, 4419, 5132, 5361, 
4418, 4394, 5139
1861, 236, 432, 235, 69, 3925, 3926, 1184, 
1979, 1539, 2052
1862, 61, 395, 228, 227, 1514, 3572, 1969, 
1968, 3574, 1176
1863, 693, 650, 691, 695, 4782, 3799, 2933, 
2991, 4745, 2938
1864, 650, 715, 648, 695, 4783, 4642, 2796, 
4745, 3013, 4796
1865, 911, 872, 569, 898, 5361, 4305, 5201, 
5133, 4303, 4304
1866, 582, 757, 492, 91, 4160, 4739, 5454, 
5271, 4741, 2016
1867, 659, 702, 634, 635, 5134, 5004, 2770, 
2771, 3813, 2700
1868, 788, 101, 930, 79, 3345, 4861, 4457, 
4653, 1345, 5000
1869, 324, 841, 937, 839, 4744, 5121, 5455, 
4904, 5188, 5220
1870, 582, 756, 492, 757, 5374, 4740, 5454, 
4160, 3213, 4739
1871, 115, 353, 269, 114, 1381, 4158, 3066, 
1063, 1382, 3065
1872, 773, 287, 288, 541, 3277, 1236, 3278, 
4313, 2205, 2204
1873, 243, 232, 233, 66, 2128, 1181, 2129, 
5099, 1976, 1977
1874, 650, 693, 691, 642, 4782, 2933, 3799, 
2743, 5321, 3798
1875, 905, 584, 557, 504, 4650, 2528, 4166, 
4164, 2438, 2513
1876, 539, 241, 74, 240, 2355, 1989, 4136, 
2354, 1189, 2053
1877, 386, 859, 387, 132, 5334, 4982, 1609, 
1409, 5312, 1412
1878, 584, 909, 503, 206, 5444, 4345, 2363, 
2328, 5311, 2097
1879, 672, 644, 707, 669, 2820, 4338, 5020, 
2823, 2822, 5071
1880, 12, 622, 11, 25, 2661, 2660, 953, 
2856, 4970, 2857
1881, 620, 671, 700, 657, 2814, 4707, 4736, 
2845, 2832, 4712
1882, 358, 789, 101, 930, 3887, 3346, 1364, 
3886, 3890, 4861
1883, 545, 544, 311, 858, 2387, 2402, 2236, 
3584, 4676, 4286
1884, 863, 917, 871, 464, 5353, 5414, 4792, 
5172, 4386, 5373
1885, 303, 834, 833, 509, 2571, 1823, 2572, 
2232, 3782, 3969
1886, 323, 842, 690, 322, 3531, 4639, 4053, 
1271, 4200, 4054
1887, 902, 904, 881, 745, 4938, 4245, 4939, 
5288, 4825, 4787
1888, 927, 191, 580, 498, 5456, 2312, 3985, 
4834, 2079, 2435
1889, 904, 903, 493, 882, 4618, 4898, 3616, 
3821, 4239, 3823
1890, 199, 582, 492, 200, 2318, 5454, 2066, 
1148, 2320, 2065
1891, 910, 727, 726, 729, 5005, 3104, 4075, 
4846, 3140, 3146
1892, 926, 780, 859, 857, 5055, 5056, 5050, 
4880, 5047, 5184
1893, 210, 44, 348, 43, 2045, 1518, 4047, 
2038, 992, 1519
1894, 720, 719, 878, 744, 3083, 4068, 5258, 
3172, 3171, 4857
1895, 369, 452, 359, 849, 1701, 1700, 1668, 
3650, 4263, 4505
1896, 771, 782, 785, 925, 3306, 3340, 3339, 
4293, 4477, 4574
1897, 324, 325, 689, 843, 1273, 5313, 5457, 
4905, 3954, 5164
1898, 938, 72, 239, 73, 4810, 1987, 5087, 
5354, 1021, 1988
1899, 904, 731, 741, 745, 4823, 3158, 4867, 
4825, 3175, 3179
1900, 876, 740, 902, 881, 4843, 4770, 4844, 
5223, 4788, 4939
1901, 192, 83, 84, 925, 2005, 1032, 2006, 
5048, 4035, 3882
1902, 858, 456, 405, 884, 5208, 1845, 3766, 
4272, 4281, 4274
1903, 573, 584, 909, 503, 2563, 5444, 4343, 
2517, 2363, 4345
1904, 347, 33, 346, 514, 1300, 1297, 1507, 
3673, 5219, 5458
1905, 236, 70, 587, 355, 1980, 4329, 2351, 
4348, 1337, 4656
1906, 732, 736, 344, 915, 3129, 3128, 3116, 
4226, 3909, 3908
1907, 676, 10, 11, 26, 4592, 952, 4969, 
2881, 2861, 2859
1908, 605, 562, 891, 537, 2555, 4036, 5459, 
2535, 2540, 3609
1909, 378, 804, 829, 805, 3741, 3492, 4506, 
3742, 3414, 3493
1910, 572, 732, 335, 344, 4225, 3117, 2428, 
2516, 3116, 1293
1911, 347, 346, 432, 514, 1507, 1538, 1537, 
3673, 5458, 5434
1912, 342, 735, 734, 574, 3124, 3126, 3122, 
2287, 5328, 5422
1913, 346, 511, 432, 514, 3968, 3927, 1538, 
5458, 2443, 5434
1914, 391, 865, 140, 394, 3879, 5290, 1420, 
1611, 4760, 1427
1915, 770, 865, 920, 394, 3518, 3519, 3520, 
3524, 4760, 4749
1916, 511, 346, 515, 514, 3968, 3964, 2480, 
2443, 5458, 2356
1917, 782, 770, 920, 769, 3318, 3520, 3517, 
3317, 3271, 4978
1918, 196, 361, 87, 88, 4372, 1354, 2011, 
2012, 1353, 1036
1919, 863, 312, 564, 554, 5412, 2404, 4795, 
5460, 2238, 2454
1920, 746, 754, 918, 761, 3245, 5408, 5461, 
3244, 3241, 4768
1921, 864, 455, 862, 860, 5437, 3945, 4308, 
4446, 4132, 5397
1922, 599, 500, 581, 864, 2484, 2347, 2485, 
4309, 4376, 5148
1923, 411, 746, 941, 917, 5410, 4999, 4094, 
4151, 5462, 5352
1924, 166, 165, 411, 746, 1114, 1466, 1465, 
3181, 3180, 5410
1925, 553, 55, 221, 222, 4335, 2040, 2338, 
2339, 1959, 1170
1926, 751, 752, 756, 492, 3198, 3238, 3237, 
4631, 4629, 4740
1927, 198, 752, 492, 756, 4353, 4629, 2068, 
5381, 3238, 4740
1928, 802, 838, 801, 524, 5307, 3958, 3386, 
4422, 3660, 5284
1929, 89, 501, 415, 755, 4923, 5209, 1562, 
4352, 4377, 4765
1930, 542, 774, 288, 601, 5441, 3280, 2207, 
2503, 3675, 2504
1931, 801, 523, 259, 524, 4472, 2162, 3382, 
5284, 2368, 2165
1932, 407, 160, 406, 318, 1458, 1455, 1628, 
5097, 4221, 5379
1933, 544, 776, 290, 289, 5016, 3286, 2210, 
2211, 3285, 1238
1934, 181, 424, 425, 883, 1493, 1640, 1496, 
4387, 4439, 4388
1935, 802, 261, 525, 260, 3387, 2166, 5029, 
3385, 1209, 2167
1936, 466, 597, 901, 872, 5463, 4661, 5464, 
5299, 4302, 4717
1937, 773, 860, 774, 768, 5426, 3874, 3282, 
3308, 4131, 3309
1938, 174, 423, 723, 183, 1489, 4442, 3091, 
1132, 1490, 3090
1939, 363, 180, 179, 724, 1491, 1128, 1492, 
4248, 3093, 3092
1940, 904, 206, 503, 909, 3751, 2097, 3752, 
4937, 5311, 4345
1941, 765, 929, 136, 767, 4436, 5214, 3255, 
3261, 3872, 3259
1942, 737, 419, 890, 418, 4413, 4381, 4414, 
4665, 1638, 4382
1943, 71, 237, 433, 238, 1982, 3623, 1540, 
1985, 1186, 5225
1944, 923, 779, 924, 607, 5169, 5168, 3829, 
5217, 5179, 5103
1945, 725, 741, 882, 883, 3148, 4237, 4438, 
3815, 3725, 4238
1946, 461, 927, 387, 435, 5337, 5366, 1736, 
1830, 4488, 1731
1947, 859, 787, 762, 780, 5053, 3330, 4890, 
5056, 3329, 3303
1948, 923, 591, 546, 607, 3827, 2396, 3975, 
5217, 2636, 2388
1949, 545, 858, 310, 848, 3584, 4620, 2237, 
3582, 3581, 4609
1950, 132, 859, 762, 780, 5312, 4890, 3246, 
3299, 5056, 3303
1951, 352, 209, 43, 42, 5423, 1938, 1313, 
1314, 1937, 991
1952, 395, 836, 868, 547, 5347, 3548, 4298, 
3573, 3707, 3706
1953, 901, 465, 413, 414, 5330, 1756, 5331, 
5336, 1755, 1635
1954, 300, 219, 552, 52, 2481, 2335, 2229, 
5279, 1955, 5465
1955, 737, 916, 719, 732, 4412, 4070, 3136, 
3167, 4747, 3168
1956, 709, 673, 656, 717, 5286, 2826, 4404, 
3010, 5466, 5467
1957, 70, 433, 587, 355, 1541, 3625, 4329, 
1337, 1587, 4656
1958, 28, 6, 21, 20, 2867, 2868, 974, 
2878, 4368, 965
1959, 219, 53, 552, 52, 1956, 5270, 2335, 
1955, 1001, 5465
1960, 773, 860, 436, 617, 5426, 4462, 5306, 
4312, 5468, 5341
1961, 773, 540, 772, 287, 3526, 3538, 3279, 
3277, 2202, 3275
1962, 545, 777, 290, 921, 4492, 3288, 2213, 
3586, 5213, 5021
1963, 923, 309, 546, 591, 3688, 2235, 3975, 
3827, 2397, 2396
1964, 834, 396, 833, 509, 4855, 4081, 1823, 
3782, 4941, 3969
1965, 907, 873, 880, 906, 5264, 4016, 4175, 
4177, 4962, 4176
1966, 317, 682, 634, 316, 4949, 5003, 2696, 
1265, 4432, 2695
1967, 445, 512, 433, 587, 4232, 3624, 1669, 
4654, 2444, 3625
1968, 721, 720, 873, 739, 3086, 3761, 3759, 
3143, 3142, 4017
1969, 79, 108, 80, 795, 1348, 1347, 1028, 
4778, 3366, 5189
1970, 272, 427, 112, 530, 5413, 1503, 3060, 
2179, 5070, 4914
1971, 687, 693, 642, 691, 2932, 5321, 4822, 
2927, 2933, 3798
1972, 377, 240, 74, 73, 4137, 2053, 1545, 
1546, 2043, 1022
1973, 468, 483, 487, 899, 1858, 1931, 1925, 
3712, 4420, 3715
1974, 157, 321, 402, 403, 5390, 4883, 1447, 
1450, 4882, 1624
1975, 608, 611, 880, 618, 2552, 5153, 4990, 
2642, 2645, 3891
1976, 803, 802, 900, 789, 3388, 5031, 5030, 
3407, 3393, 3889
1977, 802, 790, 900, 789, 3394, 5245, 5031, 
3393, 3351, 3889
1978, 366, 446, 838, 365, 1713, 3682, 3934, 
1575, 1677, 3937
1979, 597, 477, 872, 466, 5045, 5046, 4302, 
5463, 1901, 5299
1980, 346, 32, 345, 515, 1298, 1295, 1506, 
3964, 3966, 4704
1981, 910, 727, 426, 726, 5005, 5006, 4076, 
4075, 3104, 4074
1982, 53, 148, 552, 52, 1323, 5109, 5270, 
1001, 1324, 5465
1983, 366, 790, 103, 365, 3933, 3350, 1368, 
1575, 3936, 1365
1984, 300, 52, 552, 148, 5279, 5465, 2229, 
1739, 1324, 5109
1985, 857, 926, 498, 927, 4880, 5428, 5371, 
5183, 4557, 4834
1986, 639, 665, 701, 640, 2789, 5081, 4322, 
2713, 2790, 3523
1987, 625, 664, 663, 712, 2785, 2788, 2782, 
4667, 4666, 4454
1988, 82, 191, 190, 580, 2003, 1139, 2002, 
4889, 2312, 2311
1989, 931, 792, 791, 800, 3550, 3357, 3957, 
3786, 3398, 3397
1990, 191, 435, 927, 580, 5427, 4488, 5456, 
2312, 4503, 3985
1991, 353, 268, 269, 578, 4027, 1217, 4158, 
4968, 2297, 2300
1992, 353, 578, 269, 528, 4968, 2300, 4158, 
4117, 2331, 2176
1993, 814, 936, 533, 937, 4672, 5011, 5012, 
4671, 4675, 3913
1994, 934, 815, 939, 827, 3910, 4046, 4044, 
3912, 3485, 4975
1995, 440, 933, 128, 383, 5407, 5450, 1649, 
1650, 5221, 1403
1996, 815, 534, 277, 278, 5076, 2188, 3440, 
3441, 2187, 1226
1997, 644, 672, 706, 636, 2820, 5039, 4827, 
2728, 2817, 4111
1998, 735, 914, 744, 913, 5327, 4856, 3164, 
4480, 4513, 4481
1999, 385, 936, 812, 384, 4562, 5282, 3867, 
1608, 3628, 3866
2000, 291, 545, 546, 922, 2212, 2525, 2505, 
4495, 4493, 3976
2001, 922, 291, 778, 546, 4495, 3291, 3977, 
3976, 2505, 3978
2002, 595, 776, 929, 544, 4307, 4435, 4077, 
2452, 5016, 4602
2003, 575, 875, 914, 913, 4497, 4498, 4499, 
5377, 4511, 4513
2004, 922, 545, 848, 921, 4493, 3582, 5378, 
5094, 3586, 3583
2005, 814, 936, 812, 935, 4672, 5282, 2650, 
4257, 4564, 4548
2006, 191, 435, 857, 927, 5427, 3514, 3839, 
5456, 4488, 5183
2007, 724, 881, 722, 179, 4246, 4789, 3094, 
3092, 4950, 3088
2008, 703, 683, 315, 316, 2961, 4364, 5145, 
5380, 4363, 1264
2009, 151, 399, 508, 51, 1440, 3595, 5278, 
1666, 1524, 5228
2010, 306, 143, 305, 585, 2562, 2561, 1254, 
2394, 3903, 2333
2011, 396, 223, 222, 509, 3884, 1171, 5319, 
4941, 2119, 2118
2012, 775, 543, 779, 293, 4101, 5178, 3296, 
3283, 2209, 3295
2013, 148, 52, 149, 300, 1324, 1644, 1097, 
1739, 5279, 2615
2014, 373, 109, 526, 431, 1383, 3801, 4703, 
1699, 1582, 5232
2015, 4, 686, 29, 30, 5451, 2916, 2864, 
2869, 2910, 976
2016, 191, 857, 498, 927, 3839, 5371, 2079, 
5456, 5183, 4834
2017, 929, 544, 921, 858, 4602, 4677, 4624, 
5146, 4676, 3585
2018, 198, 329, 328, 756, 2090, 1277, 2467, 
5381, 3209, 3208
2019, 609, 902, 904, 503, 5411, 4938, 4683, 
2283, 4347, 3752
2020, 314, 683, 704, 684, 5291, 2962, 5405, 
5292, 2904, 2963
2021, 615, 928, 849, 927, 4006, 4262, 3986, 
3983, 4487, 3984
2022, 413, 760, 748, 747, 5205, 3230, 5060, 
4692, 3229, 3187
2023, 901, 466, 414, 416, 5464, 1758, 5336, 
4425, 1757, 1636
2024, 854, 488, 852, 856, 4452, 5182, 3579, 
3578, 5181, 3580
2025, 775, 850, 779, 543, 5089, 5170, 3296, 
4101, 4556, 5178
2026, 820, 539, 821, 829, 3768, 3769, 3460, 
3488, 5240, 2629
2027, 839, 841, 480, 843, 5188, 3938, 4532, 
3953, 5419, 5429
2028, 850, 543, 924, 779, 4556, 5177, 5435, 
5170, 5178, 5168
2029, 471, 901, 466, 414, 5266, 5464, 1786, 
1784, 5336, 1758
2030, 229, 427, 530, 228, 5418, 5070, 2346, 
1177, 5069, 2345
2031, 720, 912, 878, 420, 4330, 4541, 5258, 
4333, 4331, 5040
2032, 911, 335, 569, 572, 5195, 2274, 5201, 
4220, 2428, 2427
2033, 729, 903, 338, 730, 4912, 3794, 3108, 
3112, 4989, 3110
2034, 572, 732, 344, 915, 4225, 3116, 2516, 
4228, 4226, 3908
2035, 471, 901, 872, 466, 5266, 4717, 5159, 
1786, 5464, 5299
2036, 143, 430, 305, 585, 1530, 5375, 2561, 
3903, 4774, 2333
2037, 555, 872, 870, 602, 5362, 5062, 4756, 
2509, 4718, 5061
2038, 506, 479, 604, 352, 5176, 3783, 2531, 
4340, 1829, 5372
2039, 504, 364, 481, 877, 4185, 1835, 4165, 
4829, 4815, 4821
2040, 314, 555, 870, 602, 2241, 4756, 5293, 
2506, 2509, 5061
2041, 396, 397, 833, 509, 1620, 4080, 4081, 
4941, 4051, 3969
2042, 838, 476, 486, 366, 3980, 1920, 3591, 
3934, 1919, 1881
2043, 845, 452, 368, 369, 3919, 1714, 4930, 
3604, 1701, 1578
2044, 845, 452, 849, 928, 3919, 4263, 3651, 
3920, 3918, 4262
2045, 545, 858, 311, 310, 3584, 4286, 2236, 
2237, 4620, 1259
2046, 126, 380, 807, 125, 1397, 4831, 3419, 
1074, 1398, 3418
2047, 617, 860, 601, 773, 5468, 5469, 2598, 
4312, 5426, 3676
2048, 938, 820, 895, 824, 5443, 5238, 4179, 
4250, 3487, 4973
2049, 845, 792, 800, 799, 5445, 3398, 5470, 
3818, 3399, 3380
2050, 451, 356, 433, 851, 1696, 1643, 1697, 
4680, 4188, 5226
2051, 840, 155, 843, 476, 5315, 5162, 3951, 
4463, 1798, 4464
2052, 765, 885, 390, 929, 4201, 4203, 4204, 
4436, 4622, 5038
2053, 885, 929, 921, 884, 4622, 4624, 4625, 
4801, 5207, 4396
2054, 844, 368, 367, 792, 4929, 1577, 3555, 
3554, 3775, 3553
2055, 929, 858, 921, 884, 5146, 3585, 4624, 
5207, 4272, 4396
2056, 191, 435, 82, 83, 5427, 1555, 2003, 
2004, 1554, 1031
2057, 670, 709, 646, 696, 5287, 4716, 2811, 
5227, 2980, 5471
2058, 308, 154, 680, 688, 4205, 2892, 5453, 
5022, 2917, 2925
2059, 543, 926, 498, 590, 4554, 5428, 2500, 
2449, 4879, 2499
2060, 366, 790, 791, 103, 3933, 3354, 4010, 
1368, 3350, 3352
2061, 830, 894, 825, 892, 4253, 4063, 1771, 
4259, 4065, 4067
2062, 792, 845, 800, 844, 5445, 5470, 3398, 
3554, 4868, 3705
2063, 844, 368, 475, 367, 4929, 1806, 4664, 
3555, 1577, 1795
2064, 754, 941, 918, 563, 4998, 4090, 5408, 
5383, 5472, 5156
2065, 847, 475, 472, 441, 3859, 1907, 3901, 
3861, 1807, 1788
2066, 896, 323, 853, 934, 4039, 3534, 4276, 
4041, 3792, 3791
2067, 501, 864, 197, 415, 5440, 4853, 2088, 
5209, 4657, 4854
2068, 312, 163, 684, 685, 5114, 2903, 4628, 
4959, 2905, 2908
2069, 758, 901, 416, 565, 4427, 4425, 4424, 
5202, 4660, 4658
2070, 537, 896, 816, 535, 3611, 3612, 3613, 
2380, 4040, 5359
2071, 484, 473, 410, 861, 1924, 1936, 1867, 
4586, 5473, 4285
2072, 863, 467, 917, 464, 4953, 4149, 5353, 
5172, 1762, 4386
2073, 842, 324, 940, 323, 4743, 4162, 3533, 
3531, 1272, 3535
2074, 891, 896, 830, 816, 3608, 3502, 3849, 
3610, 3612, 3496
2075, 705, 654, 630, 629, 3843, 2755, 5433, 
3844, 2754, 2685
2076, 726, 742, 910, 729, 3150, 4913, 4075, 
3146, 3155, 4846
2077, 285, 192, 925, 590, 2081, 5048, 3744, 
2383, 2556, 4571
2078, 633, 632, 703, 657, 2694, 5143, 5144, 
2764, 2763, 5068
2079, 617, 500, 860, 436, 2613, 4445, 5468, 
5341, 4461, 4462
2080, 474, 898, 449, 897, 4315, 5370, 1793, 
4647, 4636, 3947
2081, 864, 455, 361, 941, 5437, 1718, 4375, 
4310, 4096, 4911
2082, 324, 842, 689, 323, 4743, 5250, 5457, 
1272, 3531, 5391
2083, 308, 688, 307, 844, 5022, 4319, 1256, 
4206, 4213, 4320
2084, 196, 361, 500, 87, 4372, 4374, 2086, 
2011, 1354, 4573
2085, 682, 635, 318, 317, 3811, 2699, 4222, 
4949, 2698, 1266
2086, 830, 896, 827, 816, 3502, 3504, 3497, 
3496, 3612, 3486
2087, 462, 855, 488, 445, 4102, 4451, 1933, 
1934, 4450, 1917
2088, 864, 455, 860, 361, 5437, 4132, 4446, 
4375, 1718, 4444
2089, 752, 89, 90, 172, 4354, 1038, 4630, 
3199, 1356, 1355
2090, 941, 599, 918, 563, 4086, 4088, 4090, 
5472, 2541, 5156
2091, 713, 705, 685, 311, 3002, 2966, 2995, 
3632, 4448, 3634
2092, 917, 746, 166, 411, 5462, 3181, 5474, 
4151, 5410, 1465
2093, 665, 716, 668, 648, 5343, 3931, 2842, 
2792, 4643, 2840
2094, 927, 926, 498, 543, 4557, 5428, 4834, 
4555, 4554, 2500
2095, 409, 413, 464, 871, 1855, 1753, 1852, 
4599, 4691, 5373
2096, 596, 576, 897, 502, 2461, 4058, 3779, 
2557, 2319, 4638
2097, 872, 555, 870, 899, 5362, 4756, 5062, 
4418, 5363, 4391
2098, 872, 890, 898, 911, 4419, 5131, 4303, 
5361, 5132, 5133
2099, 324, 534, 937, 940, 2542, 3914, 5455, 
4162, 5368, 4696
2100, 830, 894, 818, 825, 4253, 3755, 1773, 
1771, 4063, 1772
2101, 380, 125, 893, 807, 1398, 4992, 4837, 
4831, 3418, 4977
2102, 379, 938, 805, 378, 4811, 4251, 5376, 
1604, 5355, 3742
2103, 235, 432, 514, 68, 3926, 5434, 2348, 
2051, 1536, 5261
2104, 881, 876, 909, 902, 5223, 4902, 4325, 
4939, 4844, 4346
2105, 394, 920, 360, 85, 4749, 4750, 1617, 
1558, 5010, 1352
2106, 525, 803, 900, 496, 5027, 5030, 5028, 
2365, 3982, 3543
2107, 894, 537, 605, 891, 3754, 2535, 4921, 
3756, 3609, 5459
2108, 877, 438, 481, 879, 4816, 1836, 4821, 
4862, 4401, 5421
2109, 895, 851, 932, 893, 4317, 4191, 4956, 
5395, 4681, 4991
2110, 873, 879, 481, 469, 4960, 5421, 4198, 
4197, 4398, 1853
2111, 859, 889, 927, 387, 4892, 5136, 5051, 
4982, 4983, 5366
2112, 683, 314, 315, 870, 5291, 1263, 4364, 
4785, 5293, 4757
2113, 938, 606, 820, 513, 4178, 5424, 5443, 
4538, 2199, 4820
2114, 698, 699, 678, 321, 2950, 2949, 2944, 
3709, 4724, 5360
2115, 698, 320, 678, 679, 3708, 5175, 2944, 
2945, 3646, 2890
2116, 820, 606, 895, 819, 5424, 4181, 5238, 
3456, 5432, 4806
2117, 667, 715, 637, 650, 4241, 3963, 2802, 
2799, 4783, 2775
2118, 562, 605, 891, 852, 2555, 5459, 4036, 
3577, 4025, 4038
2119, 501, 864, 563, 581, 5440, 5152, 2420, 
2458, 5148, 2515
2120, 845, 522, 800, 844, 3809, 3703, 5470, 
4868, 3704, 3705
2121, 384, 841, 933, 440, 3626, 3629, 3627, 
1651, 4903, 5407
2122, 607, 924, 615, 543, 5103, 4007, 2643, 
2386, 5177, 2583
2123, 786, 850, 924, 779, 4581, 5435, 4752, 
3327, 5170, 5168
2124, 792, 793, 845, 368, 3360, 3603, 5445, 
3775, 5015, 4930
2125, 927, 889, 850, 924, 5136, 4582, 4559, 
5180, 4753, 5435
2126, 308, 154, 846, 680, 4205, 3747, 3770, 
5453, 2892, 3748
2127, 501, 754, 563, 864, 5382, 5383, 2420, 
5440, 5210, 5152
2128, 809, 127, 382, 126, 3424, 1401, 5192, 
3423, 1075, 1402
2129, 460, 383, 382, 887, 1733, 1607, 1734, 
4107, 4946, 4266
2130, 936, 533, 593, 935, 5011, 2590, 5218, 
4564, 5013, 3699
2131, 847, 452, 928, 472, 3916, 3918, 3899, 
3901, 1906, 3898
2132, 380, 851, 932, 356, 5101, 4191, 5431, 
1679, 4188, 4187
2133, 809, 830, 807, 892, 3495, 3494, 3425, 
5215, 4259, 4833
2134, 380, 851, 893, 932, 5101, 4681, 4837, 
5431, 4191, 4991
2135, 554, 544, 861, 311, 2401, 4604, 5425, 
2239, 2402, 4287
2136, 928, 889, 888, 461, 4981, 4755, 3900, 
4759, 4886, 4888
2137, 928, 461, 888, 472, 4759, 4888, 3900, 
3898, 1818, 3654
2138, 507, 374, 527, 351, 3921, 3922, 2362, 
4722, 1904, 4876
2139, 932, 825, 893, 806, 3721, 4066, 4991, 
3638, 3475, 4993
2140, 496, 803, 900, 930, 3982, 5030, 3543, 
5446, 4456, 3888
2141, 683, 870, 315, 869, 4785, 4757, 4364, 
4362, 4390, 4271
2142, 636, 698, 706, 679, 4110, 2975, 4111, 
5449, 2945, 2970
2143, 615, 928, 591, 849, 4006, 4008, 2644, 
3986, 4262, 4859
2144, 803, 253, 796, 930, 3391, 3367, 3405, 
4456, 5475, 4455
2145, 253, 496, 930, 803, 2158, 5446, 5475, 
3391, 3982, 4456
2146, 253, 187, 494, 930, 2075, 2058, 4985, 
5475, 5403, 5394
2147, 703, 714, 658, 657, 3000, 5140, 5239, 
5068, 4711, 2768
2148, 758, 749, 750, 416, 3233, 3193, 3234, 
4424, 4423, 4500
2149, 704, 314, 631, 632, 5405, 2687, 4483, 
5387, 2689, 2691
2150, 704, 314, 313, 631, 5405, 1262, 4482, 
4483, 2687, 2686
2151, 424, 883, 882, 493, 4439, 4238, 4140, 
5476, 5196, 3823
2152, 735, 342, 343, 574, 3124, 1291, 3125, 
5328, 2287, 2286
2153, 599, 864, 563, 941, 4309, 5152, 2541, 
4086, 4310, 5472
2154, 873, 907, 880, 913, 5264, 4175, 4016, 
4976, 4934, 4966
2155, 603, 611, 913, 574, 2550, 4972, 5329, 
2522, 2551, 5155
2156, 373, 516, 350, 349, 3997, 5350, 1814, 
1767, 4897, 1509
2157, 453, 407, 406, 318, 1748, 1628, 1749, 
4169, 5097, 5379
2158, 915, 736, 914, 744, 3909, 3907, 3906, 
5448, 3165, 4856
2159, 447, 389, 458, 886, 1715, 1726, 1725, 
4777, 5118, 4732
2160, 864, 754, 563, 941, 5210, 5383, 5152, 
4310, 4998, 5472
2161, 595, 774, 542, 860, 4079, 5441, 2451, 
4078, 3874, 5477
2162, 941, 746, 918, 917, 4999, 5461, 4090, 
5352, 5462, 5400
2163, 165, 753, 415, 411, 3226, 4062, 1473, 
1466, 5409, 1632
2164, 412, 166, 411, 917, 1468, 1465, 1633, 
4150, 5474, 4151
2165, 166, 412, 747, 917, 1468, 4689, 3182, 
5474, 4150, 5478
2166, 601, 617, 612, 860, 2598, 2601, 2567, 
5469, 5468, 5415
2167, 524, 900, 579, 525, 3666, 3542, 2486, 
2369, 5028, 2473
2168, 941, 754, 918, 746, 4998, 5408, 4090, 
4999, 3245, 5461
2169, 79, 101, 100, 788, 1345, 1049, 1707, 
4653, 3345, 3344
2170, 357, 837, 532, 454, 4522, 4113, 4545, 
1710, 4530, 4529
2171, 814, 828, 811, 936, 3483, 3482, 2649, 
4672, 4674, 3897
2172, 747, 166, 917, 746, 3182, 5474, 5478, 
3184, 3181, 5462
2173, 313, 409, 413, 870, 4596, 1855, 5206, 
4799, 4143, 5204
2174, 890, 468, 899, 483, 4383, 3712, 4394, 
4421, 1858, 4420
2175, 703, 658, 702, 634, 5239, 5141, 2972, 
5436, 2767, 5004
2176, 743, 569, 570, 898, 5200, 2429, 5211, 
4928, 4304, 4610
2177, 437, 202, 93, 502, 5259, 2021, 1567, 
5260, 2093, 5267
2178, 738, 336, 569, 335, 3134, 2273, 4634, 
3133, 1284, 2274
2179, 672, 697, 667, 619, 4780, 3529, 2818, 
2819, 5161, 2801
2180, 313, 705, 630, 312, 4627, 5433, 2684, 
1261, 4447, 2683
2181, 471, 899, 487, 483, 5157, 3715, 1928, 
1932, 4420, 1931
2182, 778, 922, 783, 777, 3977, 5084, 3325, 
3293, 4494, 3324
2183, 727, 898, 728, 897, 5059, 5212, 3139, 
5007, 4636, 3780
2184, 192, 857, 83, 925, 3838, 3513, 2005, 
5048, 4034, 4035
2185, 933, 828, 939, 937, 4535, 5119, 4701, 
4697, 4673, 4698
2186, 842, 324, 689, 843, 4743, 5457, 5250, 
5479, 4905, 5164
2187, 253, 494, 796, 930, 4985, 3696, 3367, 
5475, 5394, 4455
2188, 24, 622, 677, 623, 5273, 5275, 2884, 
3852, 2665, 3501
2189, 823, 598, 817, 274, 4669, 5149, 3467, 
3463, 2496, 3447
2190, 542, 601, 612, 860, 2503, 2567, 2566, 
5477, 5469, 5415
2191, 358, 102, 101, 789, 1363, 1050, 1364, 
3887, 3347, 3346
2192, 863, 312, 554, 861, 5412, 2238, 5460, 
5420, 4606, 5425
2193, 311, 858, 685, 310, 4286, 5174, 3634, 
1259, 4620, 3635
2194, 863, 410, 861, 484, 5171, 4285, 5420, 
4954, 1867, 4586
2195, 776, 784, 921, 777, 3322, 4626, 5017, 
3290, 3323, 5213
2196, 760, 334, 761, 568, 3223, 3225, 3224, 
5401, 2271, 4766
2197, 704, 705, 630, 313, 2967, 5433, 4484, 
4482, 4627, 2684
2198, 101, 789, 788, 930, 3346, 3348, 3345, 
4861, 3890, 4457
2199, 539, 826, 241, 536, 5302, 5249, 2355, 
2379, 5167, 2439
2200, 78, 489, 930, 494, 1996, 5318, 4860, 
2056, 2055, 5394
2201, 401, 440, 478, 841, 1880, 1812, 1843, 
5301, 4903, 5234
2202, 276, 275, 532, 813, 1224, 2184, 2183, 
3436, 3435, 4156
2203, 534, 324, 937, 593, 2542, 5455, 3914, 
2543, 2419, 3915
2204, 187, 496, 930, 253, 2074, 5446, 5403, 
2075, 2158, 5475
2205, 869, 555, 911, 899, 4216, 4217, 4219, 
3714, 5363, 5139
2206, 478, 933, 853, 841, 5392, 5222, 5235, 
5234, 3629, 4734
2207, 440, 933, 478, 841, 5407, 5392, 1812, 
4903, 3629, 5234
2208, 677, 622, 696, 649, 5275, 5193, 2969, 
4812, 2741, 4813
2209, 707, 635, 659, 669, 4337, 2771, 5104, 
5071, 2831, 2850
2210, 707, 635, 702, 659, 4337, 3813, 2994, 
5104, 2771, 5134
2211, 698, 715, 637, 708, 3007, 3963, 3710, 
2992, 3020, 4092
2212, 663, 716, 711, 668, 3930, 3009, 5357, 
2844, 3931, 5430
2213, 710, 649, 696, 670, 4214, 4813, 2982, 
4215, 2821, 5227
2214, 681, 644, 702, 706, 5138, 4339, 2958, 
2971, 4827, 2977
2215, 644, 681, 702, 635, 5138, 2958, 4339, 
2729, 3812, 3813
2216, 622, 677, 696, 676, 5275, 2969, 5193, 
4971, 2968, 2940
2217, 471, 899, 870, 487, 5157, 4391, 5158, 
1928, 3715, 4389
2218, 644, 318, 681, 635, 2726, 4223, 5138, 
2729, 2699, 3812
2219, 6, 28, 687, 20, 2867, 2911, 4565, 
4368, 2878, 2912
2220, 911, 872, 555, 569, 5361, 5362, 4217, 
5201, 4305, 2508
2221, 611, 608, 880, 574, 2552, 4990, 5153, 
2551, 2431, 5154
2222, 663, 664, 718, 712, 2788, 4761, 5356, 
4454, 4666, 3032
2223, 28, 5, 687, 29, 2866, 4566, 2911, 
975, 2865, 2915
2224, 651, 666, 718, 710, 2836, 4584, 4762, 
5480, 4684, 3028
2225, 519, 80, 490, 189, 4869, 1998, 5135, 
2310, 1999, 2061
2226, 667, 715, 708, 637, 4241, 3020, 3530, 
2802, 3963, 4092
2227, 710, 666, 652, 651, 4684, 2825, 4746, 
5480, 2836, 2750
2228, 709, 710, 696, 670, 2983, 2982, 2980, 
5287, 4215, 5227
2229, 654, 710, 709, 670, 3870, 2983, 5285, 
2843, 4215, 5287
2230, 697, 686, 619, 641, 2943, 5452, 5161, 
5160, 4005, 2795
2231, 863, 484, 861, 862, 4954, 4586, 5420, 
4955, 3943, 4589
2232, 319, 636, 706, 679, 2701, 4111, 4826, 
3718, 5449, 2970
2233, 682, 703, 634, 316, 2960, 5436, 5003, 
4432, 5380, 2695
2234, 880, 608, 734, 574, 4990, 5300, 4649, 
5154, 2431, 5422
2235, 737, 916, 419, 719, 4412, 4415, 4413, 
3136, 4070, 5128
2236, 735, 880, 734, 574, 4965, 4649, 3126, 
5328, 5154, 5422
2237, 423, 727, 723, 183, 5058, 3103, 4442, 
1490, 3102, 3090
2238, 922, 291, 777, 778, 4495, 3289, 4494, 
3977, 3291, 3293
2239, 907, 611, 880, 913, 4230, 5153, 4175, 
4934, 4972, 4966
2240, 551, 60, 227, 395, 3990, 1967, 2483, 
5335, 1533, 3574
2241, 703, 657, 632, 717, 5068, 2763, 5143, 
3014, 5067, 5388
2242, 882, 363, 96, 904, 4141, 1360, 3824, 
3821, 4247, 3822
2243, 69, 235, 68, 432, 2052, 2051, 1017, 
1539, 3926, 1536
2244, 424, 493, 882, 96, 5476, 3823, 4140, 
1570, 2024, 3824
2245, 729, 596, 728, 337, 3776, 3778, 3109, 
3107, 2456, 3106
2246, 457, 875, 912, 878, 4615, 4539, 5082, 
4517, 3557, 4541
2247, 880, 573, 734, 608, 3892, 4839, 4649, 
4990, 2545, 5300
2248, 468, 869, 487, 482, 3711, 3713, 1925, 
1866, 5265, 1888
2249, 176, 720, 878, 420, 3081, 5258, 5447, 
1484, 4333, 5040
2250, 424, 363, 96, 882, 1672, 1360, 1570, 
4140, 4141, 3824
2251, 597, 477, 362, 898, 5045, 1905, 5442, 
4301, 4316, 4328
2252, 424, 181, 725, 883, 1493, 3096, 4437, 
4439, 4387, 3815
2253, 741, 725, 882, 724, 3148, 4438, 4237, 
3147, 3097, 4621
2254, 883, 424, 425, 95, 4439, 1640, 4388, 
5197, 1571, 1568
2255, 89, 752, 90, 492, 4354, 4630, 1038, 
2069, 4629, 2015
2256, 203, 576, 910, 338, 2290, 4847, 3796, 
2094, 2291, 3797
2257, 742, 726, 910, 883, 3150, 4075, 4913, 
3727, 3814, 5198
2258, 729, 576, 338, 910, 4392, 2291, 3108, 
4846, 4847, 3797
2259, 752, 753, 415, 173, 3201, 4062, 4764, 
3200, 3202, 1474
2260, 764, 886, 389, 447, 4852, 5118, 4849, 
5092, 4777, 1715
2261, 657, 632, 717, 656, 2763, 5388, 5067, 
2765, 2761, 5467
2262, 417, 171, 751, 91, 1477, 3196, 4943, 
1595, 1564, 4742
2263, 313, 564, 871, 312, 2403, 4791, 4597, 
1261, 2404, 5115
2264, 599, 554, 862, 564, 2574, 5304, 4087, 
2595, 2454, 5333
2265, 230, 231, 262, 431, 1179, 2304, 2174, 
3999, 3998, 5237
2266, 133, 889, 388, 763, 5185, 4887, 1414, 
3248, 5199, 4561
2267, 169, 749, 414, 416, 3189, 4713, 1471, 
1476, 4423, 1636
2268, 872, 890, 443, 898, 4419, 4521, 4520, 
4303, 5131, 4441
2269, 577, 242, 349, 36, 2294, 5316, 4120, 
4841, 3045, 1306
2270, 765, 885, 929, 784, 4201, 4622, 4436, 
3315, 4380, 4623
2271, 565, 362, 583, 597, 5129, 3787, 2632, 
2589, 5442, 2464
2272, 526, 349, 64, 577, 4896, 1333, 5231, 
2470, 4120, 4121
2273, 4, 686, 619, 29, 5451, 5452, 2653, 
2864, 2916, 5481
2274, 845, 846, 847, 591, 3773, 3860, 3917, 
3774, 3772, 3830
2275, 265, 589, 118, 374, 2374, 3928, 3075, 
4003, 3923, 1386
2276, 900, 77, 358, 434, 4509, 1344, 3885, 
5346, 1549, 1585
2277, 646, 709, 673, 656, 4716, 5286, 2827, 
2808, 4404, 2826
2278, 526, 349, 373, 64, 4896, 1767, 4703, 
5231, 1333, 1724
2279, 588, 849, 497, 580, 4858, 5066, 2554, 
2558, 3987, 2330
2280, 564, 918, 568, 871, 4793, 4767, 2264, 
4791, 4790, 5402
2281, 660, 671, 707, 700, 2813, 4706, 3732, 
3731, 4707, 2973
2282, 353, 50, 49, 216, 1319, 998, 1320, 
4026, 1950, 1949
2283, 578, 50, 216, 217, 3924, 1950, 2298, 
2299, 1951, 1165
2284, 910, 203, 94, 897, 3796, 2033, 4944, 
4848, 4056, 4645
2285, 474, 502, 897, 437, 4646, 4638, 4647, 
1800, 5260, 3948
2286, 389, 441, 458, 886, 1654, 1775, 1726, 
5118, 5090, 4732
2287, 782, 771, 772, 919, 3306, 3276, 3307, 
4478, 4195, 3562
2288, 461, 927, 889, 387, 5337, 5136, 4886, 
1736, 5366, 4983
2289, 386, 859, 132, 780, 5334, 5312, 1409, 
4148, 5056, 3299
2290, 922, 848, 886, 921, 5378, 4728, 5083, 
5094, 3583, 4835
2291, 4, 5, 29, 619, 946, 2865, 2864, 
2653, 2652, 5481
2292, 837, 434, 579, 900, 4466, 4469, 4467, 
3665, 5346, 3542
2293, 849, 370, 798, 497, 5262, 3683, 3649, 
5066, 5190, 4546
2294, 5, 687, 29, 619, 4566, 2915, 2865, 
2652, 5308, 5481
2295, 576, 202, 897, 502, 2306, 4057, 4058, 
2319, 2093, 4638
2296, 496, 187, 930, 489, 2074, 5403, 5446, 
3540, 2029, 5318
2297, 256, 798, 255, 520, 3373, 3372, 1204, 
2154, 4547, 2155
2298, 840, 154, 155, 367, 4211, 1103, 5315, 
4275, 1444, 1443
2299, 325, 324, 593, 839, 1273, 2419, 2418, 
3952, 4904, 3700
2300, 901, 566, 597, 565, 4471, 2573, 4661, 
4660, 2423, 2589
2301, 840, 154, 688, 155, 4211, 2917, 4212, 
5315, 1103, 2918
2302, 606, 281, 538, 819, 2536, 2195, 2537, 
5432, 3452, 4028
2303, 715, 716, 648, 695, 3026, 4643, 4642, 
3013, 3008, 4796
2304, 840, 367, 155, 476, 4275, 1443, 5315, 
4463, 1926, 1798
2305, 320, 158, 404, 403, 3645, 1452, 3647, 
5386, 1449, 1625
2306, 894, 852, 893, 892, 4994, 3621, 4064, 
4065, 3622, 3620
2307, 686, 697, 619, 29, 2943, 5161, 5452, 
2916, 2946, 5481
2308, 380, 356, 932, 379, 1679, 4187, 5431, 
1605, 1584, 5113
2309, 820, 938, 829, 824, 5443, 4252, 3488, 
3487, 4250, 3489
2310, 512, 586, 851, 238, 2349, 4318, 5269, 
2133, 2350, 4349
2311, 692, 620, 646, 8, 5191, 2734, 4710, 
4708, 2655, 2735
2312, 512, 854, 851, 616, 4235, 5268, 5269, 
2647, 5102, 4021
2313, 697, 687, 619, 29, 2947, 5308, 5161, 
2946, 2915, 5481
2314, 378, 124, 123, 805, 1393, 1072, 1394, 
3742, 3413, 3412
2315, 932, 124, 125, 379, 3636, 1073, 3637, 
5113, 1396, 1395
2316, 840, 367, 476, 931, 4275, 1926, 4463, 
3941, 3551, 3981
2317, 900, 77, 434, 579, 4509, 1549, 5346, 
3542, 5187, 4469
2318, 606, 281, 820, 282, 2536, 3454, 5424, 
2197, 1230, 3455
2319, 903, 571, 204, 339, 4616, 2324, 4617, 
5014, 2278, 2474
2320, 826, 539, 821, 536, 5302, 3769, 2628, 
5167, 2379, 5323
2321, 856, 439, 470, 488, 5137, 1781, 3994, 
5181, 1913, 1916
2322, 817, 283, 536, 821, 3446, 2192, 5151, 
3459, 3458, 5323
2323, 569, 597, 872, 555, 2538, 4302, 4305, 
2508, 2539, 5362
2324, 593, 324, 937, 839, 2419, 5455, 3915, 
3700, 4904, 5220
2325, 665, 661, 701, 640, 2791, 5404, 5081, 
2790, 2777, 3523
2326, 864, 501, 755, 415, 5440, 4377, 5358, 
4657, 5209, 4765
2327, 416, 597, 466, 362, 4659, 5463, 1757, 
1802, 5442, 1874
2328, 277, 937, 814, 533, 5256, 4671, 3438, 
2185, 3913, 5012
2329, 279, 537, 816, 535, 2194, 3613, 3444, 
2189, 2380, 5359
2330, 828, 933, 810, 811, 4535, 4537, 3481, 
3482, 3896, 3431
2331, 283, 539, 536, 821, 2200, 2379, 2192, 
3458, 3769, 5323
2332, 699, 698, 637, 321, 2950, 3710, 3961, 
4724, 3709, 2704
2333, 786, 923, 778, 779, 3655, 3657, 3326, 
3327, 5169, 3297
2334, 159, 319, 679, 404, 3716, 3718, 2889, 
1451, 3719, 3648
2335, 583, 362, 502, 597, 3787, 3789, 2436, 
2464, 5442, 2465
2336, 625, 643, 712, 663, 2722, 4002, 4667, 
2782, 2781, 4454
2337, 24, 622, 12, 25, 5273, 2661, 2860, 
970, 4970, 2856
2338, 787, 926, 850, 775, 5052, 4558, 5054, 
3331, 5088, 5089
2339, 779, 292, 293, 607, 3294, 1241, 3295, 
5179, 2217, 2216
2340, 318, 160, 406, 681, 4221, 1455, 5379, 
4223, 2894, 5482
2341, 415, 941, 361, 411, 4910, 4911, 1592, 
1632, 4094, 1708
2342, 761, 871, 760, 568, 5417, 5255, 3224, 
4766, 5402, 5401
2343, 554, 312, 311, 861, 2238, 1260, 2239, 
5425, 4606, 4287
2344, 595, 554, 861, 862, 2507, 5425, 4603, 
5303, 5304, 4589
2345, 690, 842, 689, 156, 4639, 5250, 2924, 
2921, 4640, 2920
2346, 358, 434, 365, 900, 1585, 1676, 1574, 
3885, 5346, 5344
2347, 907, 873, 874, 912, 5264, 5072, 5253, 
5252, 4817, 5075
2348, 682, 407, 317, 318, 4948, 4409, 4949, 
4222, 5097, 1266
2349, 864, 754, 753, 755, 5210, 3242, 4919, 
5358, 3207, 3240
2350, 93, 202, 201, 502, 2021, 1150, 2020, 
5267, 2093, 2092
2351, 437, 202, 94, 93, 5259, 2022, 1566, 
1567, 2021, 1042
2352, 407, 408, 161, 875, 1629, 1460, 1457, 
4406, 4614, 5317
2353, 923, 292, 607, 546, 5295, 2217, 5217, 
3975, 2389, 2388
2354, 923, 292, 779, 607, 5295, 3294, 5169, 
5217, 2217, 5179
2355, 401, 842, 843, 841, 5251, 5479, 5332, 
5301, 4733, 5419
2356, 885, 929, 884, 390, 4622, 5207, 4801, 
4203, 5038, 4280
2357, 776, 929, 921, 784, 4435, 4624, 5017, 
3322, 4623, 4626
2358, 312, 163, 871, 684, 5114, 5116, 5115, 
4628, 2903, 4601
2359, 350, 527, 375, 351, 5393, 4875, 1815, 
1510, 4876, 1903
2360, 762, 850, 786, 787, 4579, 4581, 3333, 
3330, 5054, 3336
2361, 784, 922, 921, 777, 5093, 5094, 4626, 
3323, 4494, 5213
2362, 825, 807, 893, 806, 3476, 4977, 4066, 
3475, 3420, 4993
2363, 350, 527, 351, 252, 5393, 4876, 1510, 
5389, 2361, 5364
2364, 395, 836, 294, 141, 5347, 1820, 5112, 
1430, 1819, 1821
2365, 12, 13, 623, 24, 954, 2664, 2663, 
2860, 2862, 3852
2366, 922, 784, 783, 777, 5093, 3316, 5084, 
4494, 3323, 3324
2367, 324, 323, 689, 701, 1272, 5391, 5457, 
4321, 4323, 2953
2368, 319, 318, 406, 681, 1267, 5379, 3847, 
3717, 4223, 5482
2369, 50, 353, 578, 216, 1319, 4968, 3924, 
1950, 4026, 2298
2370, 867, 353, 114, 269, 4114, 1382, 4122, 
4152, 4158, 3065
2371, 923, 292, 778, 779, 5295, 3292, 3657, 
5169, 3294, 3297
2372, 449, 727, 426, 897, 5369, 5006, 1723, 
3947, 5007, 3946
2373, 291, 292, 778, 546, 1240, 3292, 3291, 
2505, 2389, 3978
2374, 402, 462, 403, 855, 1745, 1744, 1624, 
4104, 4102, 4885
2375, 493, 424, 95, 96, 5476, 1571, 2023, 
2024, 1570, 1044
2376, 437, 202, 897, 94, 5259, 4057, 3948, 
1566, 2022, 4645
2377, 384, 936, 480, 459, 3628, 3939, 1832, 
1730, 4534, 1834
2378, 736, 735, 914, 744, 3130, 5327, 3907, 
3165, 3164, 4856
2379, 16, 15, 674, 1, 957, 2874, 2873, 
2851, 956, 5095
2380, 584, 573, 909, 879, 2563, 4343, 5444, 
4071, 3895, 4900
2381, 478, 402, 842, 853, 1842, 4199, 5233, 
5235, 4084, 3532
2382, 731, 340, 733, 609, 3114, 3118, 3120, 
4987, 2546, 4988
2383, 740, 745, 902, 881, 3177, 5288, 4770, 
4788, 4787, 4939
2384, 933, 384, 128, 811, 3627, 1406, 5450, 
3896, 3868, 3429
2385, 846, 154, 475, 405, 3747, 1796, 3862, 
3749, 1453, 1799
2386, 703, 682, 634, 702, 2960, 5003, 5436, 
2972, 2959, 5004
2387, 448, 719, 176, 419, 5126, 3080, 1687, 
1742, 5128, 1481
2388, 325, 324, 701, 640, 1273, 4321, 3522, 
2712, 2711, 3523
2389, 688, 325, 701, 643, 4668, 3522, 2955, 
4001, 2723, 3521
2390, 405, 884, 458, 848, 4274, 4731, 1915, 
3767, 4273, 4729
2391, 689, 401, 842, 843, 5049, 5251, 5250, 
5164, 5332, 5479
2392, 846, 441, 848, 405, 3863, 5091, 3689, 
3749, 1808, 3767
2393, 191, 435, 580, 82, 5427, 4503, 2312, 
2003, 1555, 4889
2394, 928, 452, 461, 472, 3918, 1909, 4759, 
3898, 1906, 1818
2395, 500, 617, 860, 612, 2613, 5468, 4445, 
2604, 2601, 5415
2396, 914, 344, 915, 575, 3905, 3908, 3906, 
4499, 2288, 4496
2397, 874, 318, 557, 317, 4170, 2244, 4172, 
4411, 1266, 2245
2398, 814, 594, 533, 935, 4254, 2448, 5012, 
4257, 4255, 5013
2399, 159, 160, 681, 406, 1108, 2894, 2893, 
1456, 1455, 5482
2400, 308, 626, 712, 680, 2671, 4568, 5023, 
5453, 4567, 2989
2401, 908, 808, 813, 823, 4526, 3470, 4524, 
4549, 3469, 3468
2402, 324, 639, 701, 640, 2710, 4322, 4321, 
2711, 2713, 3523
2403, 688, 308, 712, 680, 5022, 5023, 2990, 
2925, 5453, 2989
2404, 935, 592, 838, 610, 3669, 3659, 3589, 
3724, 2560, 3723
2405, 655, 631, 656, 717, 2758, 2760, 2762, 
5483, 5484, 5467
2406, 704, 632, 631, 717, 5387, 2691, 4483, 
3015, 5388, 5484
2407, 501, 754, 864, 755, 5382, 5210, 5440, 
4377, 3207, 5358
2408, 24, 622, 25, 677, 5273, 4970, 970, 
2884, 5275, 2913
2409, 926, 781, 925, 590, 5025, 4294, 4881, 
4879, 4570, 4571
2410, 453, 874, 557, 481, 4171, 4172, 4032, 
1861, 5080, 4168
2411, 82, 190, 359, 580, 2002, 5033, 1349, 
4889, 2311, 4504
2412, 841, 324, 937, 940, 4744, 5455, 5121, 
4735, 4162, 4696
2413, 920, 770, 139, 769, 3520, 3268, 4751, 
4978, 3271, 3266
2414, 773, 288, 601, 541, 3278, 2504, 3676, 
4313, 2204, 2523
2415, 499, 540, 773, 541, 2466, 3526, 3527, 
2488, 2385, 4313
2416, 846, 309, 923, 591, 3686, 3688, 3690, 
3772, 2397, 3827
2417, 435, 580, 849, 927, 4503, 3987, 4264, 
4488, 3985, 3984
2418, 284, 926, 775, 543, 5485, 5088, 3284, 
2208, 4554, 4101
2419, 881, 724, 722, 745, 4246, 3094, 4789, 
4787, 3174, 3173
2420, 284, 926, 781, 775, 5485, 5025, 3300, 
3284, 5088, 3304
2421, 321, 320, 403, 678, 1269, 5386, 4882, 
5360, 5175, 5349
2422, 660, 694, 641, 15, 3730, 3805, 2773, 
5229, 2934, 4004
2423, 672, 694, 697, 641, 5019, 2942, 4780, 
2835, 3805, 5160
2424, 81, 497, 370, 359, 5032, 5190, 1552, 
1350, 5034, 1551
2425, 107, 108, 794, 370, 1056, 3364, 3362, 
1376, 1375, 3685
2426, 133, 763, 388, 134, 3248, 4561, 1414, 
1082, 3249, 1413
2427, 284, 926, 590, 781, 5485, 4879, 2384, 
3300, 5025, 4570
2428, 248, 518, 41, 31, 2146, 3864, 3043, 
3044, 5281, 990
2429, 319, 159, 681, 406, 3716, 2893, 3717, 
3847, 1456, 5482
2430, 487, 869, 408, 482, 3713, 4784, 1887, 
1888, 5265, 1885
2431, 627, 713, 652, 651, 4613, 4128, 2748, 
2747, 5165, 2750
2432, 710, 718, 651, 712, 3028, 4762, 5480, 
3030, 3032, 4763
2433, 719, 736, 915, 744, 3178, 3909, 4069, 
3171, 3165, 5448
2434, 720, 912, 739, 744, 4330, 4818, 3142, 
3172, 4964, 3166
2435, 933, 384, 440, 128, 3627, 1651, 5407, 
5450, 1406, 1649
2436, 352, 209, 42, 505, 5423, 1937, 1314, 
3807, 2101, 3808
2437, 248, 518, 249, 41, 2146, 2145, 1197, 
3043, 3864, 3054
2438, 914, 915, 744, 878, 3906, 5448, 4856, 
4512, 3561, 4857
2439, 416, 597, 901, 466, 4659, 4661, 4425, 
1757, 5463, 5464
2440, 542, 774, 601, 860, 5441, 3675, 2503, 
5477, 3874, 5469
2441, 487, 869, 870, 408, 3713, 4390, 4389, 
1887, 4784, 4144
2442, 422, 876, 881, 722, 4908, 5223, 4952, 
4951, 5294, 4789
2443, 424, 883, 493, 95, 4439, 5196, 5476, 
1571, 5197, 2023
2444, 713, 710, 651, 712, 3029, 5480, 5165, 
2997, 3030, 4763
2445, 357, 837, 495, 532, 4522, 4465, 4523, 
4545, 4113, 2612
2446, 842, 401, 478, 841, 5251, 1843, 5233, 
4733, 5301, 5234
2447, 876, 880, 740, 739, 4018, 4648, 4843, 
4019, 4020, 3151
2448, 710, 713, 651, 652, 3029, 5165, 5480, 
4746, 4128, 2750
2449, 686, 4, 3, 30, 5451, 945, 4779, 
2910, 2869, 2870
2450, 259, 523, 801, 258, 2162, 4472, 3382, 
1207, 2163, 3381
2451, 880, 735, 913, 574, 4965, 4480, 4966, 
5154, 5328, 5155
2452, 284, 926, 543, 590, 5485, 4554, 2208, 
2384, 4879, 2449
2453, 539, 826, 74, 241, 5302, 5248, 4136, 
2355, 5249, 1989
2454, 767, 860, 392, 393, 3871, 4134, 5486, 
4963, 4133, 1615
2455, 748, 413, 747, 167, 5060, 4692, 3187, 
3185, 1470, 3183
2456, 582, 756, 199, 492, 5374, 5487, 2318, 
5454, 4740, 2066
2457, 582, 756, 329, 199, 5374, 3209, 2317, 
2318, 5487, 2091
2458, 199, 198, 492, 756, 1147, 2068, 2066, 
5487, 5381, 4740
2459, 198, 199, 329, 756, 1147, 2091, 2090, 
5381, 5487, 3209
2460, 929, 774, 767, 776, 3875, 3311, 3872, 
4435, 3287, 3343
2461, 136, 929, 392, 767, 5214, 4459, 1422, 
3259, 3872, 5486
2462, 111, 273, 63, 62, 3058, 4838, 1330, 
1331, 3734, 1011
2463, 352, 506, 345, 348, 4340, 5289, 1779, 
1580, 4341, 1642
2464, 875, 907, 912, 913, 4933, 5252, 4539, 
4511, 4934, 4540
2465, 273, 229, 63, 62, 2126, 1972, 4838, 
3734, 1971, 1011
2466, 714, 671, 658, 657, 4705, 2833, 5140, 
4711, 2832, 2768
2467, 862, 455, 392, 860, 3945, 1930, 4269, 
5397, 4132, 4134
2468, 47, 589, 428, 266, 5488, 4061, 1512, 
3970, 2373, 5320
2469, 589, 507, 47, 428, 2494, 4721, 5488, 
4061, 4060, 1512
2470, 507, 589, 47, 214, 2494, 5488, 4721, 
2109, 2440, 1945
2471, 510, 58, 430, 354, 3856, 1532, 3857, 
4097, 1326, 1645
2472, 354, 304, 144, 430, 5340, 1613, 1432, 
1645, 5398, 1619
2473, 441, 846, 848, 923, 3863, 3689, 5091, 
4515, 3690, 3691
2474, 767, 860, 929, 392, 3871, 3873, 3872, 
5486, 4134, 4459
2475, 137, 393, 767, 392, 1424, 4963, 3260, 
1421, 1615, 5486
2476, 450, 511, 355, 432, 4359, 4360, 1801, 
1694, 3927, 1776
2477, 62, 272, 111, 273, 3735, 3059, 1331, 
3734, 1221, 3058
2478, 714, 657, 717, 656, 4711, 5067, 3011, 
4403, 2765, 5467
2479, 582, 417, 757, 91, 4925, 4490, 4160, 
5271, 1595, 4741
2480, 666, 622, 623, 677, 2798, 2665, 2805, 
3499, 5275, 3501
2481, 229, 427, 62, 272, 5418, 1501, 1971, 
2340, 5413, 3735
2482, 81, 82, 190, 359, 1030, 2002, 2001, 
1350, 1349, 5033
2483, 749, 901, 414, 416, 4426, 5336, 4713, 
4423, 4425, 1636
2484, 287, 540, 541, 773, 2202, 2385, 2205, 
3277, 3526, 4313
2485, 647, 668, 711, 695, 2803, 5430, 5296, 
4295, 4297, 2985
2486, 369, 793, 106, 368, 3606, 3359, 1374, 
1578, 5015, 1371
2487, 775, 787, 779, 850, 3331, 3335, 3296, 
5089, 5054, 5170
2488, 308, 309, 846, 591, 1257, 3686, 3770, 
2400, 2397, 3772
2489, 849, 370, 369, 798, 5262, 1579, 3650, 
3649, 3683, 3607
2490, 781, 285, 590, 284, 3301, 2383, 4570, 
3300, 1233, 2384
2491, 193, 865, 919, 925, 3544, 4476, 3692, 
3746, 3883, 3745
2492, 915, 572, 575, 344, 4228, 2521, 4496, 
3908, 2516, 2288
2493, 865, 782, 920, 919, 3516, 3517, 3519, 
4476, 4478, 3563
2494, 545, 777, 291, 290, 4492, 3289, 2212, 
2213, 3288, 1239
2495, 206, 877, 98, 207, 4686, 4814, 2026, 
1155, 4685, 2027
2496, 764, 885, 784, 886, 4379, 4380, 3314, 
4852, 4802, 5036
2497, 22, 15, 3, 30, 967, 3668, 2863, 
977, 2875, 2870
2498, 427, 111, 62, 272, 1500, 1331, 1501, 
5413, 3059, 3735
2499, 758, 417, 582, 565, 4489, 4925, 4159, 
5202, 4926, 2422
2500, 759, 331, 332, 566, 3217, 1280, 3218, 
4357, 2268, 2267
2501, 752, 198, 755, 756, 4353, 4351, 3239, 
3238, 5381, 3210
2502, 751, 752, 90, 172, 3198, 4630, 4632, 
3197, 3199, 1355
2503, 621, 670, 646, 696, 2812, 2811, 2769, 
5194, 5227, 5471
2504, 709, 692, 646, 696, 2981, 4710, 4716, 
2980, 2941, 5471
2505, 551, 142, 294, 306, 4124, 2594, 2226, 
2227, 2593, 1255
2506, 660, 694, 15, 674, 3730, 2934, 5229, 
4738, 2936, 2874
2507, 171, 417, 751, 750, 1477, 4943, 3196, 
3194, 4491, 3195
2508, 757, 417, 751, 91, 4490, 4943, 3236, 
4741, 1595, 4742
2509, 247, 517, 248, 31, 2144, 2143, 1196, 
3033, 5276, 3044
2510, 39, 250, 46, 40, 3051, 3817, 1499, 
988, 3052, 1315
2511, 247, 32, 345, 31, 3034, 1295, 4727, 
3033, 980, 1296
2512, 463, 320, 403, 321, 5385, 5386, 1747, 
5241, 1269, 4882
2513, 130, 385, 381, 812, 1407, 1606, 1400, 
3433, 3867, 5489
2514, 709, 714, 717, 656, 3005, 3011, 3010, 
4404, 4403, 5467
2515, 603, 575, 914, 913, 2518, 4499, 5325, 
5329, 5377, 4513
2516, 302, 835, 553, 509, 1750, 3515, 2230, 
2233, 4050, 2482
2517, 793, 792, 845, 799, 3360, 5445, 3603, 
3400, 3399, 3818
2518, 796, 494, 788, 930, 3696, 3697, 3409, 
4455, 5394, 4457
2519, 148, 54, 53, 552, 1325, 1002, 1323, 
5109, 5108, 5270
2520, 813, 935, 812, 381, 4157, 4548, 3472, 
4155, 4154, 5489
2521, 54, 220, 53, 552, 1958, 1957, 1002, 
5108, 2336, 5270
2522, 849, 370, 359, 369, 5262, 1551, 4505, 
3650, 1579, 1668
2523, 298, 550, 508, 151, 2224, 2635, 2616, 
2621, 4662, 5278
2524, 243, 242, 577, 36, 1191, 2294, 2293, 
3042, 3045, 4841
2525, 577, 231, 64, 526, 2295, 2041, 4121, 
2470, 2490, 5231
2526, 67, 35, 244, 233, 1334, 3040, 5203, 
1978, 5100, 2136
2527, 252, 38, 350, 37, 3048, 1307, 5389, 
3047, 986, 1308
2528, 242, 37, 349, 36, 3046, 1305, 5316, 
3045, 985, 1306
2529, 808, 130, 381, 812, 3421, 1400, 4527, 
3434, 3433, 5489
2530, 938, 606, 895, 820, 4178, 4181, 4179, 
5443, 5424, 5238
2531, 257, 522, 800, 799, 2161, 3703, 3378, 
3376, 5186, 3380
2532, 410, 311, 858, 685, 4283, 4286, 4284, 
4958, 3634, 5174
2533, 103, 790, 102, 365, 3350, 3349, 1051, 
1365, 3936, 1366
2534, 314, 704, 313, 684, 5405, 4482, 1262, 
5292, 2963, 4598
2535, 687, 642, 20, 691, 4822, 4209, 2912, 
2927, 3798, 2928
2536, 495, 434, 76, 185, 4468, 1550, 4758, 
2072, 5339, 1993
2537, 773, 860, 601, 774, 5426, 5469, 3676, 
3282, 3874, 3675
2538, 521, 257, 256, 799, 2156, 1205, 2157, 
3820, 3376, 3375
2539, 870, 314, 313, 684, 5293, 1262, 4799, 
5122, 5292, 4598
2540, 830, 809, 827, 887, 3495, 3479, 3497, 
3503, 5216, 3506
2541, 163, 162, 409, 684, 1111, 1462, 1461, 
2903, 2902, 4600
2542, 15, 660, 674, 1, 5229, 4738, 2874, 
956, 2774, 5095
2543, 933, 383, 810, 128, 5221, 4695, 4537, 
5450, 1403, 3427
2544, 162, 870, 409, 684, 5123, 4143, 1462, 
2902, 5122, 4600
2545, 714, 703, 658, 702, 3000, 5239, 5140, 
2999, 2972, 5141
2546, 99, 364, 429, 504, 1361, 1588, 1542, 
5125, 4185, 4184
2547, 938, 378, 829, 805, 5355, 4506, 4252, 
4251, 3742, 3493
2548, 534, 940, 939, 937, 5368, 4700, 5078, 
3914, 4696, 4698
2549, 808, 813, 812, 381, 3470, 3472, 3434, 
4527, 4155, 5489
2550, 936, 841, 839, 937, 3630, 5188, 4531, 
4675, 5121, 5220
2551, 668, 647, 711, 662, 2803, 5296, 5430, 
2834, 2780, 5297
2552, 761, 871, 747, 760, 5417, 4690, 3243, 
3224, 5255, 3229
2553, 668, 716, 711, 695, 3931, 3009, 5430, 
4297, 3008, 2985
2554, 675, 677, 711, 623, 2914, 3031, 2986, 
4240, 3501, 5298
2555, 567, 760, 568, 333, 4183, 5401, 2426, 
2269, 3221, 2272
2556, 516, 120, 375, 264, 3995, 1387, 3996, 
2170, 3078, 5044
2557, 385, 935, 454, 381, 4563, 4528, 1728, 
1606, 4154, 1711
2558, 428, 118, 117, 266, 1600, 1066, 1511, 
5320, 3074, 3073
2559, 567, 760, 313, 568, 4183, 4800, 2406, 
2426, 5401, 2578
2560, 375, 264, 120, 119, 5044, 3078, 1387, 
1388, 3077, 1068
2561, 825, 895, 932, 893, 4804, 4956, 3721, 
4066, 5395, 4991
2562, 119, 527, 264, 265, 5043, 2173, 3077, 
3076, 2172, 1213
2563, 935, 385, 812, 381, 4563, 3867, 4548, 
4154, 1606, 5489
2564, 137, 136, 392, 767, 1085, 1422, 1421, 
3260, 3259, 5486
2565, 477, 872, 471, 443, 5046, 5159, 1902, 
1805, 4520, 1935
2566, 671, 660, 620, 700, 2813, 2784, 2814, 
4707, 3731, 4736
2567, 865, 770, 140, 394, 3518, 3269, 5290, 
4760, 3524, 1427
2568, 908, 377, 74, 376, 5246, 1545, 5247, 
4895, 1603, 1548
2569, 522, 845, 800, 799, 3809, 5470, 3703, 
5186, 3818, 3380
2570, 769, 920, 436, 360, 4978, 5305, 4369, 
5399, 4750, 1591
2571, 427, 229, 62, 228, 5418, 1971, 1501, 
5069, 1177, 1970
2572, 864, 862, 599, 860, 4308, 4087, 4309, 
4446, 5397, 5396
2573, 272, 112, 271, 530, 3060, 3061, 1220, 
2179, 4914, 2180
2574, 929, 860, 595, 862, 3873, 4078, 4077, 
4587, 5397, 5303
2575, 554, 863, 862, 564, 5460, 4955, 5304, 
2454, 4795, 5333
2576, 866, 372, 399, 400, 3566, 1827, 4290, 
3802, 1886, 1622
2577, 52, 299, 149, 300, 5272, 2614, 1644, 
5279, 1248, 2615
2578, 862, 863, 918, 564, 4955, 4794, 4091, 
5333, 4795, 4793
2579, 845, 522, 521, 799, 3809, 2366, 3810, 
3818, 5186, 3820
2580, 710, 705, 654, 717, 3019, 3843, 3870, 
3018, 3017, 5439
2581, 157, 321, 690, 402, 5390, 5309, 2922, 
1447, 4883, 4641
2582, 367, 366, 476, 931, 1576, 1919, 1926, 
3551, 3979, 3981
2583, 312, 705, 685, 684, 4447, 2966, 4959, 
4628, 2965, 2908
2584, 840, 367, 931, 844, 4275, 3551, 3941, 
4000, 3555, 3552
2585, 790, 802, 900, 838, 3394, 5031, 5245, 
3935, 5307, 3667
2586, 659, 671, 658, 714, 2849, 2833, 2772, 
5105, 4705, 5140
2587, 325, 324, 689, 701, 1273, 5457, 5313, 
3522, 4321, 2953
2588, 683, 408, 869, 875, 4786, 4784, 4362, 
4431, 4614, 3556
2589, 340, 341, 733, 609, 1289, 3119, 3118, 
2546, 2281, 4988
2590, 98, 909, 877, 206, 4916, 4917, 4814, 
2026, 5311, 4686
2591, 758, 417, 757, 582, 4489, 4490, 3216, 
4159, 4925, 4160
2592, 721, 177, 178, 421, 3084, 1126, 3085, 
3760, 1486, 1485
2593, 424, 181, 180, 725, 1493, 1129, 1494, 
4437, 3096, 3095
2594, 422, 721, 178, 421, 4907, 3085, 1488, 
1639, 3760, 1485
2595, 824, 932, 805, 806, 3720, 3733, 3473, 
3474, 3638, 3417
2596, 366, 790, 838, 791, 3933, 3935, 3934, 
4010, 3354, 3956
2597, 208, 429, 505, 504, 5008, 3806, 2100, 
2099, 4184, 2102
2598, 847, 475, 846, 845, 3859, 3862, 3860, 
3917, 3932, 3773
2599, 102, 900, 789, 358, 5244, 3889, 3347, 
1363, 3885, 3887
2600, 446, 837, 365, 434, 3681, 5345, 1677, 
1678, 4466, 1676
2601, 881, 363, 179, 724, 4244, 1492, 4950, 
4246, 4248, 3092
2602, 422, 881, 438, 179, 4952, 4327, 1927, 
1487, 4950, 1690
2603, 881, 363, 438, 179, 4244, 1594, 4327, 
4950, 1492, 1690
2604, 710, 654, 709, 717, 3870, 5285, 2983, 
3018, 5439, 3010
2605, 666, 664, 718, 662, 2828, 4761, 4584, 
2806, 2829, 4585
2606, 705, 704, 630, 717, 2967, 4484, 5433, 
3017, 3015, 5438
2607, 88, 864, 197, 196, 4577, 4853, 2013, 
2012, 4373, 1145
2608, 588, 798, 256, 520, 3988, 3373, 2358, 
2359, 4547, 2154
2609, 520, 797, 519, 497, 4575, 4870, 2364, 
2533, 4576, 2462
2610, 790, 900, 365, 838, 5245, 5344, 3936, 
3935, 3667, 3937
2611, 825, 807, 892, 893, 3476, 4833, 4067, 
4066, 4977, 3620
2612, 385, 936, 935, 812, 4562, 4564, 4563, 
3867, 5282, 4548
2613, 240, 938, 239, 73, 4863, 5087, 1188, 
2043, 5354, 1988
2614, 894, 537, 538, 605, 3754, 2381, 4996, 
4921, 2535, 2534
2615, 582, 91, 492, 200, 5271, 2016, 5454, 
2320, 2017, 2065
2616, 362, 93, 92, 201, 1357, 1041, 1358, 
3788, 2020, 2019
2617, 44, 518, 41, 211, 4048, 3864, 1520, 
1939, 2148, 3865
2618, 673, 655, 656, 717, 2847, 2762, 2826, 
5466, 5483, 5467
2619, 583, 362, 92, 201, 3787, 1358, 4942, 
2322, 3788, 2019
2620, 494, 78, 79, 930, 2056, 1027, 2057, 
5394, 4860, 5000
2621, 891, 852, 887, 856, 4038, 4384, 4385, 
4037, 3580, 4108
2622, 856, 439, 887, 470, 5137, 4267, 4108, 
3994, 1781, 4109
2623, 505, 604, 558, 444, 2530, 2529, 2520, 
5314, 3784, 4591
2624, 598, 274, 536, 817, 2496, 2191, 2475, 
5149, 3447, 5151
2625, 439, 382, 887, 470, 1648, 4266, 4267, 
1781, 1780, 4109
2626, 395, 868, 398, 371, 4298, 4836, 1685, 
1664, 5367, 1768
2627, 109, 110, 262, 431, 1058, 3056, 3055, 
1582, 1581, 5237
2628, 277, 937, 815, 814, 5256, 5077, 3440, 
3438, 4671, 3442
2629, 473, 456, 410, 861, 1791, 1846, 1936, 
5473, 5490, 4285
2630, 929, 456, 861, 858, 5037, 5490, 4588, 
5146, 5208, 4288
2631, 231, 577, 64, 65, 2295, 4121, 2041, 
2049, 4119, 1013
2632, 55, 397, 396, 222, 1525, 1620, 1528, 
1959, 4336, 5319
2633, 34, 347, 234, 245, 1299, 3671, 5322, 
3038, 3672, 2303
2634, 813, 908, 531, 532, 4524, 4550, 4371, 
4156, 4543, 2498
2635, 72, 938, 379, 73, 4810, 4811, 1544, 
1021, 5354, 1543
2636, 929, 473, 861, 456, 4458, 5473, 4588, 
5037, 1791, 5490
2637, 677, 718, 711, 662, 3027, 3025, 3031, 
3500, 4585, 5297
2638, 34, 67, 234, 347, 1504, 2042, 5322, 
1299, 1336, 3671
2639, 346, 33, 515, 514, 1297, 3965, 3964, 
5458, 5219, 2356
2640, 412, 871, 917, 464, 4688, 5414, 4150, 
1754, 5373, 4386
2641, 54, 831, 147, 553, 5111, 2280, 1743, 
5230, 4242, 4243
2642, 567, 760, 332, 901, 4183, 3220, 2270, 
5342, 4725, 4877
2643, 347, 34, 33, 245, 1299, 982, 1300, 
3672, 3038, 3037
2644, 761, 917, 747, 871, 5416, 5478, 3243, 
5417, 5414, 4690
2645, 314, 567, 602, 870, 2405, 2425, 2506, 
5293, 4798, 5061
2646, 397, 54, 147, 553, 1526, 1743, 1435, 
4052, 5230, 4243
2647, 303, 510, 304, 834, 2617, 2576, 1252, 
2571, 3781, 1614
2648, 901, 760, 748, 413, 4725, 3230, 4726, 
5331, 5205, 5060
2649, 553, 55, 397, 54, 4335, 1525, 4052, 
5230, 1003, 1526
2650, 47, 266, 428, 117, 3970, 5320, 1512, 
1317, 3073, 1511
2651, 380, 379, 932, 125, 1605, 5113, 5431, 
1398, 1395, 3637
2652, 243, 232, 36, 577, 2128, 4842, 3042, 
2293, 2292, 4841
2653, 33, 246, 514, 245, 3036, 2137, 5219, 
3037, 1194, 2138
2654, 241, 908, 184, 598, 4098, 4100, 1190, 
2476, 4670, 2478
2655, 235, 511, 514, 432, 2130, 2443, 2348, 
3926, 3927, 5434
2656, 258, 523, 801, 800, 2163, 4472, 3381, 
3379, 3701, 3383
2657, 870, 760, 567, 901, 4797, 4183, 4798, 
5063, 4725, 5342
2658, 283, 539, 821, 282, 2200, 3769, 3458, 
1231, 2201, 3457
2659, 448, 719, 878, 176, 5126, 4068, 4519, 
1687, 3080, 5447
2660, 717, 654, 655, 630, 5439, 2759, 5483, 
5438, 2755, 2757
2661, 615, 588, 580, 849, 2584, 2558, 2581, 
3986, 4858, 3987
2662, 860, 768, 393, 767, 4131, 3674, 4133, 
3871, 3264, 4963
2663, 922, 923, 886, 848, 3974, 5085, 5083, 
5378, 3691, 4728
2664, 289, 774, 288, 542, 3281, 3280, 1237, 
2206, 5441, 2207
2665, 134, 886, 763, 441, 4850, 4851, 3249, 
1652, 5090, 4560
2666, 476, 839, 480, 843, 4270, 4532, 1870, 
4464, 3953, 5429
2667, 266, 589, 214, 47, 2373, 2440, 2110, 
3970, 5488, 1945
2668, 551, 395, 294, 142, 5335, 5112, 2226, 
4124, 1429, 2594
2669, 654, 709, 717, 673, 5285, 3010, 5439, 
2846, 5286, 5466
2670, 655, 654, 717, 673, 2759, 5439, 5483, 
2847, 2846, 5466
2671, 837, 446, 365, 838, 3681, 1677, 5345, 
3640, 3682, 3937
2672, 176, 720, 719, 878, 3081, 3083, 3080, 
5447, 5258, 4068
2673, 448, 719, 916, 878, 5126, 4070, 5127, 
4519, 4068, 3643
2674, 704, 631, 630, 717, 4483, 2688, 4484, 
3015, 5484, 5438
2675, 407, 485, 874, 453, 1892, 5074, 4410, 
1748, 1893, 4171
2676, 556, 907, 317, 875, 4231, 4775, 2242, 
4935, 4933, 4407
2677, 631, 655, 630, 717, 2758, 2757, 2688, 
5484, 5483, 5438
2678, 631, 632, 656, 717, 2691, 2761, 2760, 
5484, 5388, 5467
2679, 907, 874, 557, 317, 5253, 4172, 4776, 
4775, 4411, 2245
2680, 908, 826, 823, 817, 5166, 3477, 4549, 
5150, 3491, 3467
2681, 638, 699, 321, 322, 3960, 4724, 2706, 
2707, 5310, 1270
2682, 285, 919, 193, 286, 3743, 3692, 2082, 
1234, 3693, 2603
2683, 561, 322, 321, 855, 2252, 1270, 2253, 
5106, 4106, 4884
2684, 692, 621, 646, 696, 4709, 2769, 4710, 
2941, 5194, 5471
2685, 761, 917, 746, 747, 5416, 5462, 3244, 
3243, 5478, 3184
2686, 621, 16, 676, 692, 4595, 2882, 4593, 
4709, 2931, 2930
2687, 891, 830, 887, 892, 3849, 3503, 4385, 
4260, 4259, 4268
2688, 911, 335, 738, 569, 5195, 3133, 4873, 
5201, 2274, 4634
2689, 731, 903, 730, 339, 4866, 4989, 3115, 
3113, 5014, 3111
2690, 731, 340, 571, 339, 3114, 2277, 5096, 
3113, 1288, 2278
2691, 852, 605, 891, 894, 4025, 5459, 4038, 
4994, 4921, 3756
2692, 56, 55, 396, 222, 1004, 1528, 1527, 
1960, 1959, 5319
2693, 609, 902, 733, 904, 5411, 5254, 4988, 
4683, 4938, 4824
2694, 894, 537, 818, 538, 3754, 3757, 3755, 
4996, 2381, 4059
2695, 350, 527, 252, 516, 5393, 2361, 5389, 
5350, 2371, 2142
2696, 838, 802, 801, 790, 5307, 3386, 3958, 
3935, 3394, 3395
2697, 252, 350, 38, 351, 5389, 1307, 3048, 
5364, 1510, 1310
2698, 375, 264, 527, 516, 5044, 2173, 4875, 
3996, 2170, 2371
2699, 823, 598, 908, 817, 4669, 4670, 4549, 
3467, 5149, 5150
2700, 817, 274, 536, 283, 3447, 2191, 5151, 
3446, 1232, 2192
2701, 753, 752, 415, 755, 3201, 4764, 4062, 
3240, 3239, 4765
2702, 553, 55, 54, 221, 4335, 1003, 5230, 
2338, 2040, 2039
2703, 900, 803, 789, 930, 5030, 3407, 3889, 
3888, 4456, 3890
2704, 412, 871, 747, 917, 4688, 4690, 4689, 
4150, 5414, 5478
2705, 603, 556, 575, 913, 2527, 2510, 2518, 
5329, 4936, 5377
2706, 595, 542, 612, 860, 2451, 2566, 2586, 
4078, 5477, 5415
2707, 898, 570, 728, 596, 4610, 5098, 5212, 
4637, 2457, 3778
2708, 232, 243, 36, 66, 2128, 3042, 4842, 
1976, 5099, 1301
2709, 791, 838, 801, 790, 3956, 3958, 3396, 
3354, 3935, 3395
2710, 727, 898, 723, 728, 5059, 4443, 3103, 
3139, 5212, 3141
2711, 936, 935, 839, 459, 4564, 3588, 4531, 
4534, 3663, 4533
2712, 446, 366, 838, 486, 1713, 3934, 3682, 
1882, 1881, 3591
2713, 476, 401, 843, 480, 1797, 5332, 4464, 
1870, 1869, 5429
2714, 842, 324, 843, 841, 4743, 4905, 5479, 
4733, 4744, 5419
2715, 840, 839, 838, 476, 3949, 3592, 3940, 
4463, 4270, 3980
2716, 430, 510, 304, 305, 3857, 2576, 5398, 
5375, 2341, 1253
2717, 898, 743, 723, 728, 4928, 3153, 4443, 
5212, 3152, 3141
2718, 721, 876, 739, 873, 4906, 4019, 3143, 
3759, 4015, 4017
2719, 786, 850, 889, 924, 4581, 4582, 4583, 
4752, 5435, 4753
2720, 664, 663, 718, 662, 2788, 5356, 4761, 
2829, 2839, 4585
2721, 831, 301, 552, 300, 1693, 2228, 5110, 
1738, 1249, 2229
2722, 763, 764, 783, 886, 3253, 3313, 3312, 
4851, 4852, 5086
2723, 838, 931, 840, 476, 3942, 3941, 3940, 
3980, 3981, 4463
2724, 220, 553, 54, 221, 2337, 5230, 1958, 
1169, 2338, 2039
2725, 182, 727, 426, 183, 3101, 5006, 1498, 
1131, 3102, 1497
2726, 556, 611, 913, 603, 2553, 4972, 4936, 
2527, 2550, 5329
2727, 456, 858, 410, 861, 5208, 4284, 1846, 
5490, 4288, 4285
2728, 929, 473, 484, 861, 4458, 1924, 4460, 
4588, 5473, 4586
2729, 743, 569, 738, 570, 5200, 4634, 3170, 
5211, 2429, 4633
2730, 313, 409, 871, 413, 4596, 4599, 4597, 
5206, 1855, 4691
2731, 929, 595, 861, 862, 4077, 4603, 4588, 
4587, 5303, 4589
2732, 477, 872, 443, 898, 5046, 4520, 1805, 
4316, 4303, 4441
2733, 597, 477, 466, 362, 5045, 1901, 5463, 
5442, 1905, 1874
2734, 554, 863, 861, 862, 5460, 5420, 5425, 
5304, 4955, 4589
2735, 484, 410, 467, 863, 1867, 1860, 1868, 
4954, 5171, 4953
2736, 855, 562, 561, 322, 5107, 2415, 5106, 
4106, 2255, 2252
2737, 842, 323, 853, 322, 3531, 3534, 3532, 
4200, 1271, 4083
2738, 413, 760, 747, 871, 5205, 3229, 4692, 
4691, 5255, 4690
2739, 323, 896, 853, 322, 4039, 4276, 3534, 
1271, 4012, 4083
2740, 323, 639, 645, 701, 2709, 2733, 2731, 
4323, 4322, 5042
2741, 507, 374, 351, 428, 3921, 1904, 4722, 
4060, 1599, 1698
2742, 699, 638, 645, 322, 3960, 2745, 5041, 
5310, 2707, 2730
2743, 761, 917, 918, 746, 5416, 5400, 4768, 
3244, 5462, 5461
2744, 768, 393, 436, 860, 3674, 1837, 4370, 
4131, 4133, 4462
2745, 748, 749, 759, 901, 3190, 3232, 3231, 
4726, 4426, 4470
2746, 907, 873, 912, 913, 5264, 4817, 5252, 
4934, 4976, 4540
